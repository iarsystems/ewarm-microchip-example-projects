# IAR project AT91RM9200-BMP-EK-IAR.ewp, settings and files
configuration FlashMemory (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91RM9200EK Microchip AT91RM9200EK
  ICCARM.CCIncludePath2: /..//include; /bmps
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: AT91RM9200-BMP-EK-IAR.out
  ILINK.IlinkIcfFile: config/FlashAT91RM9200_EK.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashRelease (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group BMPs
    bmps/: 0.c 1.c 2.c 3.c 4.c 6.c 7.c
  group common
    ./: at91_cstartup.s init.c
  group modulus
    ./: drv_1523.c drv_twi.c s1d13806.c sys_tmr.c
