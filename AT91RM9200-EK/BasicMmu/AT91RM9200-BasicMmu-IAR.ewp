# IAR project AT91RM9200-BasicMmu-IAR.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91RM9200EK Microchip AT91RM9200EK
  ICCARM.CCDefines: AT91RM9200
  ICCARM.CCDiagSuppress: Pe549,Pe177,Pe170
  ICCARM.CCIncludePath2: \..\\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: AT91RM9200-BasicMmu-IAR.out
  ILINK.IlinkIcfFile: config/FlashAT91RM9200_EK.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c mmu.c
  group common
    ./: at91_cstartup.s init.c
  group Dhrystone
    ./: dhry_1.c dhry_2.c
