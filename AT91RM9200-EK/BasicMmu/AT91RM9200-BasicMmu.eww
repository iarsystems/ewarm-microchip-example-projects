<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/AT91RM9200-BasicMmu-IAR.ewp</path>
  </project>
  <batchBuild/>
</workspace>
