# IAR project AT91RM9200-GettingStarted-EK-IAR.ewp, settings and files
configuration FlashMemory (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91RM9200EK Microchip AT91RM9200EK
  ICCARM.CCDefines: AT91RM9200
  ICCARM.CCIncludePath2: /..//include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: AT91RM9200-GettingStarted-EK-IAR.out
  ILINK.IlinkIcfFile: config/FlashAT91RM9200_EK.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration iRamMemory (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/iRamAT91RM9200_EK.icf
  group (top)
    ./: main.c
  group common
    ./: at91_cstartup.s init.c
