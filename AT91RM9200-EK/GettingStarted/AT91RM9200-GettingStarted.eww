<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/AT91RM9200-GettingStarted-EK-IAR.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>AT91RM9200-GettingStarted-EK-IAR</project>
        <configuration>FlashMemory</configuration>
      </member>
      <member>
        <project>AT91RM9200-GettingStarted-EK-IAR</project>
        <configuration>iRamMemory</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
