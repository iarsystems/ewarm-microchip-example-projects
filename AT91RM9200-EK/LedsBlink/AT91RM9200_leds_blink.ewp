# IAR project AT91RM9200_leds_blink.ewp, settings and files
configuration Debug Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91RM9200EK Microchip AT91RM9200EK
  ICCARM.CCIncludePath2: ..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: AT91RM9200_leds_blink.out
  ILINK.IlinkIcfFile: config/FlashAT91RM9200_EK.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug iRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/iRamAT91RM9200_EK.icf
  group (top)
    ./: at91_cstartup.s main.c
