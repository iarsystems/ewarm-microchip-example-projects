<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/AT91RM9200_leds_blink.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>AT91RM9200_leds_blink</project>
        <configuration>Debug Flash</configuration>
      </member>
      <member>
        <project>AT91RM9200_leds_blink</project>
        <configuration>Debug iRAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
