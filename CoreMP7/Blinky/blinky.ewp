# IAR project blinky.ewp, settings and files
configuration Debug RAM (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkIcfFile: CoreMP7_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: blinky.c
