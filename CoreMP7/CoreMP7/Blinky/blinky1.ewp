# IAR project blinky1.ewp, settings and files
configuration Debug RAM (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: blinky1.out
  ILINK.IlinkIcfFile: CoreMP7_ram.icf
  group (top)
    ./: blinky1.c
