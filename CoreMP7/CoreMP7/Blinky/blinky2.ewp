# IAR project blinky2.ewp, settings and files
configuration Debug RAM (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: blinky2.out
  ILINK.IlinkIcfFile: CoreMP7_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: blinky2.c
