<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CM1_interrupt_rx.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CM1_interrupt_rx</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CM1_interrupt_rx</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
