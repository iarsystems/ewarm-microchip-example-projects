# IAR project CM1_round_robin.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Cortex-M1 Microchip Cortex-M1
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\CMSIS\Core\Include; hal; hal/CortexM1; hal/CortexM1/EWARM; drivers/CoreAI; drivers/CoreUARTapb
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CM1_round_robin.bin
  ILINK.IlinkOutputFile: CM1_round_robin.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group drivers/CoreAI
    drivers/CoreAI/: cai_calibration.c coreai.c coreai_cfg.c
  group drivers/CoreUARTapb
    drivers/CoreUARTapb/: core_uart_apb.c
  group hal
    hal/CortexM1/: cortex_nvic.c
    hal/CortexM1/EWARM/: default_handlers.c hal_assert.c hw_reg_access.s vector_table.s
