# IAR project CM1_simple_gpio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Cortex-M1 Microchip Cortex-M1
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\CMSIS\Core\Include; hal; hal/CortexM1; hal/CortexM1/EWARM; drivers/CoreGPIO
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: CM1_simple_gpio.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group drivers/CoreGPIO
    drivers/CoreGPIO/: core_gpio.c
  group hal
    hal/CortexM1/: cortex_nvic.c
    hal/CortexM1/EWARM/: default_handlers.c hal_assert.c hw_reg_access.s vector_table.s
