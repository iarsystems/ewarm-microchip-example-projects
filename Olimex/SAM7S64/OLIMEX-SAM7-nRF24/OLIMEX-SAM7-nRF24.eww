<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RfVirtualCom/RfVirtualCom.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>RfVirtualCom</project>
        <configuration>Node A Debug</configuration>
      </member>
      <member>
        <project>RfVirtualCom</project>
        <configuration>Node B Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
