# IAR project RfVirtualCom.ewp, settings and files
configuration Node A Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM7S64 Microchip AT91SAM7S64
  ICCARM.CCDefines: NODEA; NRF24_SELF_TEST
  ICCARM.CCIncludePath2: app; board; modules; Include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: Include
  OBJCOPY.OOCOutputFile: RfVirtualComNodeA.bin
  ILINK.IlinkOutputFile: RfVirtualCom.out
  ILINK.IlinkIcfFile: config/at91SAM7S64_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Node B Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NODEB; NRF24_SELF_TEST
  OBJCOPY.OOCOutputFile: RfVirtualComNodeB.bin
  group (top)
    app/: main.c
  group NRF
    app/: nrf_drv.c RF.c
  group NRF/HW
    app/: nrf_drv_low.c
  group Others
    config/: at91SAM7S64_FLASH.icf SAM7_FLASH.mac
    VirCOM_Driver_XP/: olimexvcpdrv.inf
    ./: readme.txt
  group Ring Buffer
    modules/: ring_buffer.c
  group Startup
    board/: Cstartup.s Cstartup_SAM7.c
  group USB/Class
    app/: cd_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
