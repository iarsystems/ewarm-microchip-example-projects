# IAR project SAM7_EX256.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Microchip AT91SAM7X256
  ICCARM.CCIncludePath2: board\; module\; config\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: SAM7_EX256.out
  ILINK.IlinkIcfFile: config/at91SAM7X256_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: adc.c lcd.c main.c system.c Temperature.c
    board/: arm_comm.h
    module/: ntc.c RTT.c
