<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SAM7_EX256.ewp</path>
  </project>
  <batchBuild/>
</workspace>
