<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/eww-at91sam9g10-ek/dataflash2sdram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/eww-at91sam9g10-ek/eeprom2sdram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/eww-at91sam9g10-ek/nandflash2sdram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/eww-at91sam9g10-ek/sdcard2sdram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/eww-at91sam9g10-ek/serialflash2sdram.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>dataflash2sdram</project>
        <configuration>Slot A (On Board)</configuration>
      </member>
	  <member>
        <project>eeprom2sdram</project>
        <configuration>TWI (On Board)</configuration>
      </member>
      <member>
        <project>nandflash2sdram</project>
        <configuration>EBI (On Board)</configuration>
      </member>
      <member>
        <project>sdcard2sdram</project>
        <configuration>MCI (External)</configuration>
      </member>
      <member>
        <project>serialflash2sdram</project>
        <configuration>Slot A (On Board)</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
