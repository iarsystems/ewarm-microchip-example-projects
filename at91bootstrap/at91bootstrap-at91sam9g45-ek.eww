<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/eww-at91sam9g45-ek/dataflash2ddram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/eww-at91sam9g45-ek/eeprom2ddram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/eww-at91sam9g45-ek/nandflash2ddram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/eww-at91sam9g45-ek/sdcard2ddram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/eww-at91sam9g45-ek/serialflash2ddram.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>dataflash2ddram</project>
        <configuration>Slot A (On Board)</configuration>
      </member>
      <member>
        <project>eeprom2ddram</project>
        <configuration>TWI (On Board)</configuration>
      </member>
      <member>
        <project>nandflash2ddram</project>
        <configuration>EBI (On Board)</configuration>
      </member>
      <member>
        <project>sdcard2ddram</project>
        <configuration>MCI (External)</configuration>
      </member>
      <member>
        <project>serialflash2ddram</project>
        <configuration>Slot A (On Board)</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
