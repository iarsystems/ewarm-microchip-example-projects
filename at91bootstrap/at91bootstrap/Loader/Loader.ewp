# IAR project Loader.ewp, settings and files
configuration sama7g54ek_qspi_boot (ARM, debug)
  General.OGChipSelectEditMenu: SAMA7G54 Microchip SAMA7G54
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Loader.srec
  ILINK.IlinkOutputFile: Loader.out
  ILINK.IlinkKeepSymbols: __BOOT
  ILINK.IlinkConfigDefines: BOOTSTRATP_LOAD=0x20000000
  ILINK.IlinkIcfFile: Loader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sama7g54ek_noboot (ARM, debug)
  as the first configuration, except:
configuration sama7d65_curiosity_qspi_boot (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAMA7D65 Microchip SAMA7D65
configuration sama7d65_curiosity_noboot (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAMA7D65 Microchip SAMA7D65
configuration sam9x75_curiosity_qspi_boot (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM9X75 Microchip SAM9X75
  General.CoreVariant: 12
  General.FPU2: 0
  ILINK.IlinkConfigDefines: BOOTSTRATP_LOAD=0x60000000
configuration sam9x75_curiosity_noboot (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM9X75 Microchip SAM9X75
  General.CoreVariant: 12
  General.FPU2: 0
  ILINK.IlinkConfigDefines: BOOTSTRATP_LOAD=0x60000000
configuration sama5d29_curiosity_qspi_boot (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMA5D29 Microchip ATSAMA5D29
  General.CoreVariant: 12
  General.FPU2: 0
  ILINK.IlinkConfigDefines: BOOTSTRATP_LOAD=0xD8000000
configuration sama5d29_curiosity_noboot (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMA5D29 Microchip ATSAMA5D29
  General.CoreVariant: 12
  General.FPU2: 0
  ILINK.IlinkConfigDefines: BOOTSTRATP_LOAD=0xD8000000
  group (top)
    ./: empty.c
