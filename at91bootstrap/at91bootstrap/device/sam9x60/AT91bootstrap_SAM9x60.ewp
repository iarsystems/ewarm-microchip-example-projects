# IAR project AT91bootstrap_SAM9x60.ewp, settings and files
configuration sam9x60_curiosity_noboot (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: AT91BOOTSTRAP_VERSION="4.0.11"; TOP_OF_MEMORY=0x310000; MACH_TYPE=3373; CONFIG_DEBUG; BANNER="\n\nAT91Bootstrap " AT91BOOTSTRAP_VERSION " (" __DATE__ " " __TIME__  ")\n\n"; BOARD_MAINOSC=24000000; CONFIG_DDR2; CONFIG_DDR_1_GBIT; CONFIG_PMC_MCK_CLK; BOOTSTRAP_DEBUG_LEVEL=DEBUG_INFO
  ICCARM.PreInclude: cfg_sam9x60_curiosity_noboot.h
  ICCARM.CCIncludePath2: ..\..\include; ..\..\include\arch; ..\..\include\arch\at91_pmc; ..\..\include\arch\at91-qspi; ..\..\include\spi_flash; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MACH_TYPE=3373
  AARM.AUserIncludes: ..\..\include
  AARM.PreInclude: cfg_sam9x60_curiosity_noboot.h
  OBJCOPY.OOCOutputFile: ..\..\bin\$CONFIG_NAME$.bin
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CONFIG_LINK_ADDR=0x300000; CONFIG_BOOTSTRAP_MAXSIZE=65536
  ILINK.IlinkIcfFile: ../../AT91bootstrap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: cstartup.s main.c
  group device/sam9x60
    ./: sam9x60.c
  group driver
    ../../driver/: act8865.c at24xx.c at91_aes.c at91_aicredir.c at91_flexcom.c at91_mci.c at91_pio.c at91_pit.c at91_rstc.c at91_slowclk.c at91_spi.c at91_twi.c at91_usart.c at91_wdt.c at91_wdt2.c at91_xdmac.c backup.c board_hw_info.c board_hw_init.c common.c dataflash.c ddramc.c debug.c ds24xx.c flash.c hamming.c hdmi_SiI9022.c l1cache.c led.c load_kernel.c lp310_l2cc.c macb.c matrix.c mci_media.c mcp16502.c mmu.c nandflash.c pit64b.c pm.c pmecc.c publ.c sdcard.c sdhc.c sdramc.c secure.c sfrbu.c shdwc.c spi_flash.c svc_mgr.c tz_utils.c tzc400.c umctl2.c wm8904.c
  group driver/at91-qspi
    ../../driver/at91-qspi/: qspi-common.c qspi-sama7g5.c qspi.c
  group driver/pmc
    ../../driver/pmc/: clk-common.c generic-clk.c master-clk-sama7g5.c master-clk.c periph-clk-sam9x5.c pll-clk-sam9x60.c pll-clk.c utmi-clk.c
  group driver/spi_flash
    ../../driver/spi_flash/: sfdp.c spi_flash.c spi_nor.c spi_nor_ids.c
  group fs/source
    ../../fs/src/: diskio.c ff.c
  group fs/source/option
    ../../fs/src/option/: ccsbcs.c
  group lib
    ../../lib/: consttime_memequal.c div.c eabi_utils.c fdt.c string.c
