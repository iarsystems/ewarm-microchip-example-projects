# IAR project nandflash2sdram.ewp, settings and files
configuration EBI (On Board) (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM9263 Microchip AT91SAM9263
  ICCARM.CCDefines: at91sam9263; ORIGIN_nandflash; DESTINATION_sdram; FROM_ADDR=0x20000; DEST_ADDR=0x20000000; BIN_SIZE=0x30000; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..; ..\..\at91lib; ..\..\at91lib\boards\at91sam9263-ek; ..\..\at91lib\peripherals; ..\..\at91lib\memories; ..\..\at91lib\utility
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: at91sam9263
  AARM.AUserIncludes: ..; ..\..\at91lib; ..\..\at91lib\peripherals; ..\..\at91lib\memories; ..\..\at91lib\utility; ..\..\at91lib\boards\at91sam9263-ek
  OBJCOPY.OOCOutputFile: at91bootstrap-at91sam9263-ek-nandflash2sdram.bin
  ILINK.IlinkOutputFile: at91bootstrap-at91sam9263-ek-nandflash2sdram.out
  ILINK.IlinkIcfFile: ../../at91lib/boards/at91sam9263-ek/at91sam9263/sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group at91lib/boards/at91sam9263-ek
    ../../at91lib/boards/at91sam9263-ek/: board.h board_cstartup_iar.s board_lowlevel.c board_memories.c board_memories.h
  group at91lib/boards/at91sam9263-ek/at91sam9263
    ../../at91lib/boards/at91sam9263-ek/at91sam9263/: AT91SAM9263.h sram.icf
  group at91lib/memories/nandflash
    ../../at91lib/memories/nandflash/: EccNandFlash.c EccNandFlash.h NandFlashModel.c NandFlashModel.h NandFlashModelList.c NandFlashModelList.h NandSpareScheme.c NandSpareScheme.h RawNandFlash.c RawNandFlash.h SkipBlockNandFlash.c SkipBlockNandFlash.h
  group at91lib/peripherals/cp15
    ../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../at91lib/peripherals/irq/: aic.c
  group at91lib/peripherals/pio
    ../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/utility
    ../../at91lib/utility/: assert.h hamming.c hamming.h trace.c trace.h
  group at91sam9263-ek/at91bootstrap
    ../: boot.h BootNand.c main.c main.h
  group documentation
    ../../: flashloaders.html
    ../../documentation/: index.html
  group resources
    ../../resources/iar/: at91sam9263-ek-sram.mac
