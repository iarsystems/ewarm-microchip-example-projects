# IAR project dataflash2sdram.ewp, settings and files
configuration Slot A (On Board) (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM9G10 Microchip AT91SAM9G10
  ICCARM.CCDefines: at91sam9g10; ORIGIN_dataflash; DESTINATION_sdram; AT45_SLOT_A; OP_BOOTSTRAP_on; FROM_ADDR=0x8400; DEST_ADDR=0x20000000; BIN_SIZE=0x30000; TRACE_LEVEL=0
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..; ..\..\at91lib; ..\..\at91lib\boards\at91sam9g10-ek; ..\..\at91lib\peripherals; ..\..\at91lib\memories
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9g10
  AARM.AUserIncludes: ..\..\at91lib; ..\..\at91lib\peripherals; ..\..\at91lib\boards\at91sam9g10-ek
  OBJCOPY.OOCOutputFile: at91bootstrap-at91sam9g10-ek-dataflash2sdram.bin
  ILINK.IlinkOutputFile: at91bootstrap-at91sam9g10-ek-dataflash2sdram.out
  ILINK.IlinkIcfFile: ../../at91lib/boards/at91sam9g10-ek/at91sam9g10/sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group at91lib/boards/at91sam9g10-ek
    ../../at91lib/boards/at91sam9g10-ek/: board.h board_cstartup_iar.s board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h
  group at91lib/boards/at91sam9g10-ek/at91sam9g10
    ../../at91lib/boards/at91sam9g10-ek/at91sam9g10/: AT91SAM9G10.h chip.h sram.icf
  group at91lib/memories/spi-flash
    ../../at91lib/memories/spi-flash/: at45.c at45.h at45d.c at45d.h spid.c spid.h
  group at91lib/peripherals/cp15
    ../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../at91lib/peripherals/irq/: aic.c
  group at91lib/peripherals/pio
    ../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/utility
    ../../at91lib/utility/: assert.h trace.c trace.h
  group at91sam9g10-ek/at91bootstrap
    ../: boot.h BootAT45.c main.c main.h
  group documentation
    ../../: flashloaders.html
    ../../documentation/: index.html
  group resources
    ../../resources/iar/: at91sam9g10-ek-sram.mac
