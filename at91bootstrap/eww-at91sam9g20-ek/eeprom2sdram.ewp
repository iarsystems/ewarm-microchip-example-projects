# IAR project eeprom2sdram.ewp, settings and files
configuration TWI(External) (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9G20 Microchip AT91SAM9G20
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: at91sam9g20; ORIGIN_eeprom; DESTINATION_sdram; FROM_ADDR=0x4000; DEST_ADDR=0x20000000; BIN_SIZE=0x30000; TRACE_LEVEL=4; AT24C512
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..; ..\..\at91lib; ..\..\at91lib\boards\at91sam9g20-ek; ..\..\at91lib\drivers; ..\..\at91lib\memories; ..\..\at91lib\peripherals
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam9g20
  AARM.AUserIncludes: ..\..\at91lib; ..\..\at91lib\drivers; ..\..\at91lib\peripherals; ..\..\at91lib\boards\at91sam9g20-ek
  OBJCOPY.OOCOutputFile: at91bootstrap-at91sam9g20-ek-eeprom2sdram.bin
  ILINK.IlinkOutputFile: at91bootstrap-at91sam9g20-ek-eeprom2sdram.out
  ILINK.IlinkIcfFile: ../../at91lib/boards/at91sam9g20-ek/at91sam9g20/sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group at91lib/boards/at91sam9g20-ek
    ../../at91lib/boards/at91sam9g20-ek/: board.h board_cstartup_iar.s board_lowlevel.c board_memories.c board_memories.h
  group at91lib/boards/at91sam9g20-ek/at91sam9g20
    ../../at91lib/boards/at91sam9g20-ek/at91sam9g20/: AT91SAM9G20.h sram.icf
  group at91lib/drivers/async
    ../../at91lib/drivers/async/: async.c async.h
  group at91lib/drivers/twi
    ../../at91lib/drivers/twi/: twid.c twid.h
  group at91lib/peripherals/cp15
    ../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../at91lib/peripherals/irq/: aic.c
  group at91lib/peripherals/pio
    ../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/twi
    ../../at91lib/peripherals/twi/: twi.c twi.h
  group at91lib/utility
    ../../at91lib/utility/: assert.h math.c math.h trace.c trace.h
  group at91sam9g20-ek/at91bootstrap
    ../: boot.h BootEeprom.c main.c main.h
  group documentation
    ../../: flashloaders.html
    ../../documentation/: index.html
  group resources
    ../../resources/iar/: at91sam9g20-ek-sram.mac
