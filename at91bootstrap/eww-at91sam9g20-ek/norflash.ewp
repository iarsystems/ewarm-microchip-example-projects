# IAR project norflash.ewp, settings and files
configuration EBI (External) (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9G20 Microchip AT91SAM9G20
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: at91sam9g20; ORIGIN_norflash; DESTINATION_sdram; FROM_ADDR=0x8000; DEST_ADDR=0x20000000; BIN_SIZE=0x30000; TRACE_LEVEL=4; norflash
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..; ..\..\at91lib; ..\..\at91lib\boards\at91sam9g20-ek; ..\..\at91lib\peripherals; ..\..\at91lib\components; ..\..\at91lib\usb
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam9g20
  AARM.AUserIncludes: ..\..\at91lib; ..\..\at91lib\peripherals; ..\..\at91lib\boards\at91sam9g20-ek
  OBJCOPY.OOCOutputFile: at91bootstrap-at91sam9g20-ek-norflash2sdram.bin
  ILINK.IlinkOutputFile: at91bootstrap-at91sam9g20-ek-norflash2sdram.out
  ILINK.IlinkIcfFile: ../../at91lib/boards/at91sam9g20-ek/at91sam9g20/norflash.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group at91lib/boards/at91sam9g20-ek
    ../../at91lib/boards/at91sam9g20-ek/: board.h board_cstartup_iar.s board_lowlevel.c board_memories.c board_memories.h
  group at91lib/boards/at91sam9g20-ek/at91sam9g20
    ../../at91lib/boards/at91sam9g20-ek/at91sam9g20/: AT91SAM9G20.h norflash.icf
  group at91lib/memories/norflash
    ../../at91lib/memories/norflash/: NorFlashAmd.c NorFlashAmd.h NorFlashApi.c NorFlashApi.h NorFlashCFI.c NorFlashCFI.h NorFlashCommon.c NorFlashCommon.h NorFlashIntel.c NorFlashIntel.h
  group at91lib/peripherals/cp15
    ../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../at91lib/peripherals/irq/: aic.c
  group at91lib/peripherals/pio
    ../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/utility
    ../../at91lib/utility/: assert.h trace.c trace.h
  group at91sam9g20-ek/at91bootstrap
    ../: boot.h BootNor.c main.c main.h
  group documentation
    ../../: flashloaders.html
    ../../documentation/: index.html
  group resources
    ../../resources/iar/: at91sam9g20-ek-sram.mac
