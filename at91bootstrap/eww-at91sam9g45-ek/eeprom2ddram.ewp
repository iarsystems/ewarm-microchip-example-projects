# IAR project eeprom2ddram.ewp, settings and files
configuration TWI(External) (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM9G45 Microchip AT91SAM9G45
  ICCARM.CCDefines: at91sam9g45; ORIGIN_eeprom; DESTINATION_ddram; FROM_ADDR=0x4000; DEST_ADDR=0x70000000; BIN_SIZE=0xC000; TRACE_LEVEL=4; AT24C512
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..; ..\..\at91lib; ..\..\at91lib\boards\at91sam9g45-ek; ..\..\at91lib\drivers; ..\..\at91lib\memories; ..\..\at91lib\peripherals
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9g45
  AARM.AUserIncludes: ..\..\at91lib; ..\..\at91lib\drivers; ..\..\at91lib\peripherals; ..\..\at91lib\boards\at91sam9g45-ek
  OBJCOPY.OOCOutputFile: at91bootstrap-at91sam9g45-ek-eeprom2ddram.bin
  ILINK.IlinkOutputFile: at91bootstrap-at91sam9g45-ek-eeprom2ddram.out
  ILINK.IlinkIcfFile: ../../at91lib/boards/at91sam9g45-ek/at91sam9g45/sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group at91lib/boards/at91sam9g45-ek
    ../../at91lib/boards/at91sam9g45-ek/: board.h board_cstartup_iar.s board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h
  group at91lib/boards/at91sam9g45-ek/at91sam9g45
    ../../at91lib/boards/at91sam9g45-ek/at91sam9g45/: AT91SAM9G45.h chip.h sram.icf
  group at91lib/drivers/async
    ../../at91lib/drivers/async/: async.c async.h
  group at91lib/drivers/twi
    ../../at91lib/drivers/twi/: twid.c twid.h
  group at91lib/peripherals/cp15
    ../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../at91lib/peripherals/irq/: aic.c
  group at91lib/peripherals/pio
    ../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/twi
    ../../at91lib/peripherals/twi/: twi.c twi.h
  group at91lib/utility
    ../../at91lib/utility/: assert.h math.c math.h trace.c trace.h
  group at91sam9g45-ek/at91bootstrap
    ../: boot.h BootEeprom.c main.c main.h
  group documentation
    ../../: flashloaders.html
    ../../documentation/: index.html
  group resources
    ../../resources/iar/: at91sam9g45-ek-sram.mac
