# IAR project sdcard2ddram.ewp, settings and files
configuration MCI (External) (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM9G45 Microchip AT91SAM9G45
  ICCARM.CCDefines: at91sam9g45; ORIGIN_sdcard; DESTINATION_ddram; FILE_NAME="appli.bin"; DEST_ADDR=0x70000000; BIN_SIZE=0x30000; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..; ..\..\at91lib; ..\..\at91lib\boards\at91sam9g45-ek; ..\..\at91lib\drivers; ..\..\at91lib\peripherals; ..\..\at91lib\memories; ..\..\at91lib\utility; ..\..\external_libs\fat
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: at91sam9g45
  AARM.AUserIncludes: ..\..\at91lib; ..\..\at91lib\peripherals; ..\..\at91lib\boards\at91sam9g45-ek
  OBJCOPY.OOCOutputFile: at91bootstrap-at91sam9g45-ek-sdcard2ddram.bin
  ILINK.IlinkOutputFile: at91bootstrap-at91sam9g45-ek-sdcard2ddram.out
  ILINK.IlinkIcfFile: ../../at91lib/boards/at91sam9g45-ek/at91sam9g45/sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group at91lib/boards/at91sam9g45-ek
    ../../at91lib/boards/at91sam9g45-ek/: board.h board_cstartup_iar.s board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h
  group at91lib/boards/at91sam9g45-ek/at91sam9g45
    ../../at91lib/boards/at91sam9g45-ek/at91sam9g45/: AT91SAM9G45.h chip.h sram.icf
  group at91lib/drivers/dmad
    ../../at91lib/drivers/dmad/: dmad.c dmad.h
  group at91lib/memories
    ../../at91lib/memories/: Media.c Media.h MEDSdcard.c MEDSdcard.h
  group at91lib/memories/sdmmc
    ../../at91lib/memories/sdmmc/: sdmmc_mci.c sdmmc_mci.h
  group at91lib/peripherals/cp15
    ../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/dma
    ../../at91lib/peripherals/dma/: dma.c dma.h
  group at91lib/peripherals/irq
    ../../at91lib/peripherals/irq/: aic.c
  group at91lib/peripherals/mci
    ../../at91lib/peripherals/mci/: mci_hs.c mci_hs.h
  group at91lib/peripherals/pio
    ../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/utility
    ../../at91lib/utility/: assert.h trace.c trace.h
  group at91sam9g45-ek/at91bootstrap
    ../: boot.h BootSdcard.c fatfs_config.h main.c main.h
  group documentation
    ../../: flashloaders.html
    ../../documentation/: index.html
  group external_libs/fat/fatfs/src
    ../../external_libs/fat/fatfs/src/: diskio.c diskio.h ff_util.h tff.c tff.h
  group resources
    ../../resources/iar/: at91sam9g45-ek-sram.mac
