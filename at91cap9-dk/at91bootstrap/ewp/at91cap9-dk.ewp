# IAR project at91cap9-dk.ewp, settings and files
configuration at91cap9_sram (ARM, debug)
  General.OGChipSelectEditMenu: at91cap9 Microchip at91cap9
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: at91cap9; sram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib; ..\..\..\at91lib\boards\at91cap9-dk; ..\..\..\at91lib/drivers; ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib/memories; ..\..\..\external_libs/fat; ..\..\..\at91cap9-dk\at91bootstrap
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91cap9; sram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91cap9-dk
  OBJCOPY.OOCOutputFile: at91cap9_sram.bin
  ILINK.IlinkOutputFile: at91cap9_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91cap9-dk/at91cap9/sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91cap9_bcram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91cap9; bcram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ..\..\..\at91lib; ..\..\..\at91lib/boards/at91cap9-dk; ..\..\..\at91lib/drivers; ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib/memories; ..\..\..\external_libs/fat; ..\..\..\at91cap9-dk\at91bootstrap
  AARM.ADefines: at91cap9; bcram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91cap9_bcram.bin
  ILINK.IlinkOutputFile: at91cap9_bcram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91cap9-dk/at91cap9/bcram.icf
  group at91bootstrap
    ../: boot.h BootAT26.c BootAT45.c BootEeprom.c BootNand.c BootNor.c BootSdcard.c fatfs_config.h main.c main.h StartupScreen.ewsample
  group at91lib/boards/at91cap9-dk
    ../../../at91lib/boards/at91cap9-dk/: board.h board.mak board_cstartup_iar.s board_fpga_init.c board_fpga_init.h board_lowlevel.c board_memories.c board_memories.h
  group at91lib/boards/at91cap9-dk/at91cap9
    ../../../at91lib/boards/at91cap9-dk/at91cap9/: AT91CAP9.h sram.icf
  group at91lib/drivers/async
    ../../../at91lib/drivers/async/: async.c async.h
  group at91lib/drivers/dmad
    ../../../at91lib/drivers/dmad/: dmad.c dmad.h
  group at91lib/drivers/twi
    ../../../at91lib/drivers/twi/: twid.c twid.h
  group at91lib/memories
    ../../../at91lib/memories/: Media.c Media.h MEDSdcard.c MEDSdcard.h
  group at91lib/memories/nandflash
    ../../../at91lib/memories/nandflash/: EccNandFlash.c EccNandFlash.h NandCommon.h NandFlashModel.c NandFlashModel.h NandFlashModelList.c NandFlashModelList.h NandSpareScheme.c NandSpareScheme.h RawNandFlash.c RawNandFlash.h SkipBlockNandFlash.c SkipBlockNandFlash.h
  group at91lib/memories/norflash
    ../../../at91lib/memories/norflash/: NorFlashAmd.c NorFlashAmd.h NorFlashApi.c NorFlashApi.h NorFlashCFI.c NorFlashCFI.h NorFlashCommon.c NorFlashCommon.h NorFlashIntel.c NorFlashIntel.h
  group at91lib/memories/sdmmc
    ../../../at91lib/memories/sdmmc/: sdmmc_mci.c sdmmc_mci.h
  group at91lib/memories/spi-flash
    ../../../at91lib/memories/spi-flash/: at26.c at26.h at26d.c at26d.h at45.c at45.h at45d.c at45d.h spid.c spid.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/dma
    ../../../at91lib/peripherals/dma/: dma.c dma.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/mci
    ../../../at91lib/peripherals/mci/: mci.c mci.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/twi
    ../../../at91lib/peripherals/twi/: twi.c twi.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h hamming.c hamming.h math.c math.h trace.c trace.h
  group documentation
    ../../../: flashloaders.html
    ../../../documentation/: index.html
  group external_libs/fat/fatfs/src
    ../../../external_libs/fat/fatfs/src/: diskio.c diskio.h ff_util.h integer.h tff.c tff.h
  group resources
    ../../../resources/iar/: at91cap9-dk-sram.mac
