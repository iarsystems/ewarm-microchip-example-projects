# IAR project at91cap9-dk.ewp, settings and files
configuration at91cap9_sram (ARM, debug)
  General.OGChipSelectEditMenu: at91cap9 Microchip at91cap9
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: at91cap9; sram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91cap9-dk
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91cap9; sram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91cap9-dk
  OBJCOPY.OOCOutputFile: at91cap9_sram.bin
  ILINK.IlinkOutputFile: at91cap9_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91cap9-dk/at91cap9/sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group at91lib/boards/at91cap9-dk
    ../../../at91lib/boards/at91cap9-dk/: board.h board_cstartup_iar.s board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h
  group at91lib/boards/at91cap9-dk/at91cap9
    ../../../at91lib/boards/at91cap9-dk/at91cap9/: AT91CAP9.h bcram.icf chip.h ddram.icf sdram.icf sram.icf
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.h
  group at91lib/peripherals/rtt
    ../../../at91lib/peripherals/rtt/: rtt.c rtt.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group basic-dhrystone-project
    ../: main.c
  group documentation
    ../../../: flashloaders.html
    ../../../documentation/: index.html
  group external_libs/dhry
    ../../../external_libs/dhry/: dhry.h dhry_1.c dhry_2.c
  group resources
    ../../../resources/iar/: at91cap9-dk-bcram.mac at91cap9-dk-ddram.mac at91cap9-dk-sdram.mac at91cap9-dk-sram.mac
