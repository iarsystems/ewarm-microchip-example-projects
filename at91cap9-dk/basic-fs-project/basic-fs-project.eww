<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
	<project>
		<path>$WS_DIR$/ewp/at91cap9-dk.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>All</name>&gt;
			<member>
				<project>at91cap9-dk</project>
				<configuration>at91cap9_sdram</configuration>
			</member>
			<member>
				<project>at91cap9-dk</project>
				<configuration>at91cap9_ddram</configuration>
			</member>
			<member>
				<project>at91cap9-dk</project>
				<configuration>at91cap9_bcram</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
