# IAR project at91cap9-dk.ewp, settings and files
configuration at91cap9_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91cap9 Microchip at91cap9
  ICCARM.CCDefines: at91cap9; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/memories; ..\..\..\at91lib; ..\..\..\at91lib/boards/at91cap9-dk
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91cap9; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91cap9-dk
  OBJCOPY.OOCOutputFile: at91cap9_sdram.bin
  ILINK.IlinkOutputFile: at91cap9_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91cap9-dk/at91cap9/sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91cap9_ddram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91cap9; ddram; TRACE_LEVEL=4
  AARM.ADefines: at91cap9; ddram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91cap9_ddram.bin
  ILINK.IlinkOutputFile: at91cap9_ddram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91cap9-dk/at91cap9/ddram
configuration at91cap9_bcram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91cap9; bcram; TRACE_LEVEL=4
  AARM.ADefines: at91cap9; bcram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91cap9_bcram.bin
  ILINK.IlinkOutputFile: at91cap9_bcram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91cap9-dk/at91cap9/bcram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91cap9-dk
    ../../../at91lib/boards/at91cap9-dk/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91cap9-dk/at91cap9
    ../../../at91lib/boards/at91cap9-dk/at91cap9/: AT91CAP9.h chip.h sram.icf sdram.icf ddram.icf bcram.icf
  group at91lib/memories/norflash
    ../../../at91lib/memories/norflash/: NorFlashAmd.c NorFlashAmd.h NorFlashApi.c NorFlashApi.h NorFlashCFI.c NorFlashCFI.h NorFlashCommon.c NorFlashCommon.h NorFlashIntel.c NorFlashIntel.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h math.c math.h trace.c trace.h
  group basic-norflash-project
    ../../../at91cap9-dk/basic-norflash-project/: main.c
  group resources
    ../../../resources/iar/: at91cap9-dk-sram.mac at91cap9-dk-sdram.mac at91cap9-dk-ddram.mac at91cap9-dk-bcram.mac
