# IAR project at91cap9-stk.ewp, settings and files
configuration at91cap9_sram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91cap9 Microchip at91cap9
  ICCARM.CCDefines: at91cap9; sram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib; ..\..\..\at91lib/peripherals; ..\..\..\external_libs/fat; ..\..\..\at91lib/memories; ..\..\..\external_libs; ..\..\..\external_libs/fat/efsl; ..\..\..\external_libs/fat/efsl/src; ..\..\..\external_libs/fat/efsl/inc; ..\..\..\external_libs/fat/efsl/conf; ..\..\..\external_libs/fat/efsl/src/interfaces; ..\..\..\external_libs/fat/efsl/inc/interfaces; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91cap9-stk
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91cap9; sram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91cap9-stk
  OBJCOPY.OOCOutputFile: at91cap9_sram.bin
  ILINK.IlinkOutputFile: at91cap9_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91cap9-stk/at91cap9/sram
  ILINK.IlinkProgramEntryLabel: resetHandler
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group .
    ../../../at91cap9-stk/: basic-fatefsl-project
  group at91lib/boards/at91cap9-stk
    ../../../at91lib/boards/at91cap9-stk/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91cap9-stk/at91cap9
    ../../../at91lib/boards/at91cap9-stk/at91cap9/: AT91CAP9.h chip.h sdram.icf sram.icf
  group at91lib/memories
    ../../../at91lib/memories/: MEDDdram.c MEDDdram.h MEDFlash.h MEDSdram.c MEDSdram.h Media.c Media.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group external_libs/fat/efsl/conf
    ../../../external_libs/fat/efsl/conf/: config.h
  group external_libs/fat/efsl/inc
    ../../../external_libs/fat/efsl/inc/: debug.h dir.h disc.h efs.h error.h extract.h fat.h file.h fs.h interface.h debug.h types.h ioman.h ls.h mkfs.h partition.h plibc.h time.h types.h ui.h
  group external_libs/fat/efsl/inc/interfaces
    ../../../external_libs/fat/efsl/inc/interfaces/: at91sam7s_spi.h
  group external_libs/fat/efsl/src
    ../../../external_libs/fat/efsl/src/: debug.c dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group external_libs/fat/efsl/src/interfaces
    ../../../external_libs/fat/efsl/src/interfaces/: at91sam7s_sdram.c
  group basic-fatefsl-project
    ../../../at91cap9-stk/basic-fatefsl-project/: main.c
  group resources
    ../../../resources/iar/: at91cap9-stk-sdram.mac at91cap9-stk-sram.mac
