# IAR project at91cap9-stk.ewp, settings and files
configuration at91cap9_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91cap9 Microchip at91cap9
  ICCARM.CCDefines: at91cap9; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/drivers; ..\..\..\at91lib/memories; ..\..\..\at91lib; ..\..\..\external_libs/crc; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91cap9-stk
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91cap9; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91cap9-stk
  OBJCOPY.OOCOutputFile: at91cap9_sdram.bin
  ILINK.IlinkOutputFile: at91cap9_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91cap9-stk/at91cap9/sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91cap9-stk
    ../../../at91lib/boards/at91cap9-stk/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91cap9-stk/at91cap9
    ../../../at91lib/boards/at91cap9-stk/at91cap9/: AT91CAP9.h chip.h sdram.icf sram.icf
  group at91lib/memories/sdmmc
    ../../../at91lib/memories/sdmmc/: sdmmc_mci.c sdmmc_mci.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/mci
    ../../../at91lib/peripherals/mci/: mci.c mci.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/rtc
    ../../../at91lib/peripherals/rtc/: rtc.h
  group at91lib/peripherals/tc
    ../../../at91lib/peripherals/tc/: tc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group external_libs/crc
    ../../../external_libs/crc/: crc-itu-t.c crc-itu-t.h crc7.c crc7.h linuxtypes.h
  group basic-sdcard-project
    ../../../at91cap9-stk/basic-sdcard-project/: main.c
  group resources
    ../../../resources/iar/: at91cap9-stk-sdram.mac at91cap9-stk-sram.mac
