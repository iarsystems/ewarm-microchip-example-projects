# IAR project at91_ebxx.ewp, settings and files
configuration flashcode-EB40A (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91EB40A Microchip AT91EB40A
  ICCARM.CCDefines: FLASHCODE=1; AT91_EB40A
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: FLASHCODE=1
  ILINK.IlinkOutputFile: at91_ebxx.out
  ILINK.IlinkIcfFile: at91_lnk_eb40a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ramcode-EB40A (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91M55800 Microchip AT91M55800
  ICCARM.CCDefines: RAMCODE=1; AT91_EB40A=1
  AARM.ADefines: RAMCODE=1
  ILINK.IlinkIcfFile: at91_lnk_eb40a_ram.icf
configuration ramcode-EBxx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91M55800 Microchip AT91M55800
  ICCARM.CCDefines: RAMCODE=1
  AARM.ADefines: RAMCODE=1
  ILINK.IlinkIcfFile: at91_lnk_ram.icf
configuration flashcode-EBxx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91EB55 Microchip AT91EB55
  ICCARM.CCDefines: FLASHCODE=1
  ILINK.IlinkIcfFile: at91_lnk_flash.icf
  group (top)
    ./: readme.txt
  group Common sources
    ./: at91.c at91_cstartup.s at91_low_level_init.c button.c config.h main.c timer.c uart.c
  group flash sources
    ./: at91_lnk_eb40a_flash.icf at91_lnk_flash.icf
  group ram sources
    ./: at91_lnk_eb40a_ram.icf at91_lnk_ram.icf
