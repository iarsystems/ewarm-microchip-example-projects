# IAR project AT91RM9200_Test.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91RM9200DK Microchip AT91RM9200DK
  ICCARM.CCIncludePath2: ..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: AT91RM9200_Test.out
  ILINK.IlinkIcfFile: config/AT91RM9200-DK_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/AT91RM9200-DK_flash.icf
  group (top)
    ./: cstartup.s Debug_FLASH.mac Debug_RAM.mac low_level_init.c main.c
