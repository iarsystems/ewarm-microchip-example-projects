<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/AT91RM9200_Test.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>AT91RM9200_Test</project>
        <configuration>Debug_FLASH</configuration>
      </member>
      <member>
        <project>AT91RM9200_Test</project>
        <configuration>Debug_RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
