# IAR project at91sam3u-ek.ewp, settings and files
configuration at91sam3u4_flash (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U4E Microchip ATSAM3U4E
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: at91sam3u4; flash; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91sam3u-ek\basic-fatfs-nandflash-project; ..\..\..\at91lib; ..\..\..\at91lib/peripherals; ..\..\..\external_libs/fat; ..\..\..\at91lib/memories; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam3u-ek
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam3u4; flash; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam3u-ek
  OBJCOPY.OOCOutputFile: at91sam3u4_flash.bin
  ILINK.IlinkOutputFile: at91sam3u4_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam3u-ek/at91sam3u4/flash.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group .
    ../../: basic-fatfs-nandflash-project
  group at91lib/boards/at91sam3u-ek
    ../../../at91lib/boards/at91sam3u-ek/: board.h board_cstartup_iar.c board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h exceptions.c exceptions.h
  group at91lib/boards/at91sam3u-ek/at91sam3u4
    ../../../at91lib/boards/at91sam3u-ek/at91sam3u4/: AT91SAM3U4.h chip.h flash.icf psram.icf sram.icf
  group at91lib/memories
    ../../../at91lib/memories/: Media.c Media.h MEDNandFlash.c MEDNandFlash.h
  group at91lib/memories/nandflash
    ../../../at91lib/memories/nandflash/: EccNandFlash.c EccNandFlash.h ManagedNandFlash.c ManagedNandFlash.h MappedNandFlash.c MappedNandFlash.h NandCommon.h NandFlashModel.c NandFlashModel.h NandFlashModelList.c NandFlashModelList.h NandSpareScheme.c NandSpareScheme.h RawNandFlash.c RawNandFlash.h TranslatedNandFlash.c TranslatedNandFlash.h
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h hamming.c hamming.h math.c math.h trace.c trace.h
  group basic-fatfs-nandflash-project
    ../: fatfs_config.h main.c
  group documentation
    ../../../: flashloaders.html
    ../../../documentation/: index.html
  group external_libs/fat/fatfs/src
    ../../../external_libs/fat/fatfs/src/: diskio.c diskio.h ff.c ff.h ff_util.c ff_util.h integer.h tff.c
  group resources
    ../../../resources/iar/: at91sam3u-ek-flash.mac at91sam3u-ek-psram.mac at91sam3u-ek-sram.mac
