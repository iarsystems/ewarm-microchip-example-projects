# IAR project at91sam3u-ek.ewp, settings and files
configuration at91sam3u4_sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U4E Microchip ATSAM3U4E
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: at91sam3u4; sram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib/drivers; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam3u-ek
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam3u4; sram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam3u-ek
  OBJCOPY.OOCOutputFile: at91sam3u4_sram.bin
  ILINK.IlinkOutputFile: at91sam3u4_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam3u-ek/at91sam3u4/sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam3u4_flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam3u4; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam3u4; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam3u4_flash.bin
  ILINK.IlinkOutputFile: at91sam3u4_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam3u-ek/at91sam3u4/flash.icf
  group .
    ../../: basic-touchscreen-project
  group at91lib/boards/at91sam3u-ek
    ../../../at91lib/boards/at91sam3u-ek/: board.h board_cstartup_iar.c board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h exceptions.c exceptions.h
  group at91lib/boards/at91sam3u-ek/at91sam3u4
    ../../../at91lib/boards/at91sam3u-ek/at91sam3u4/: AT91SAM3U4.h chip.h flash.icf psram.icf sram.icf
  group at91lib/components/ads7843
    ../../../at91lib/components/ads7843/: ads7843.c ads7843.h
  group at91lib/components/hx8347
    ../../../at91lib/components/hx8347/: hx8347.c hx8347.h
  group at91lib/drivers/lcd
    ../../../at91lib/drivers/lcd/: color.h draw.h draw_hx8347.c font.c font.h font10x14.h lcdd.h lcdd_hx8347.c
  group at91lib/drivers/tsd
    ../../../at91lib/drivers/tsd/: tsd.h tsd_ads7843.c tsd_com.c tsd_com.h tsd_tsadc.c
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: irq.h nvic.c
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/spi
    ../../../at91lib/peripherals/spi/: spi.c spi.h
  group at91lib/peripherals/systick
    ../../../at91lib/peripherals/systick/: systick.c systick.h
  group at91lib/peripherals/tsadcc
    ../../../at91lib/peripherals/tsadcc/: tsadcc.c
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group basic-touchscreen-project
    ../: main.c
  group documentation
    ../../../: flashloaders.html
    ../../../documentation/: index.html
  group external_libs/cmsis
    ../../../external_libs/cmsis/: core_cm3.c core_cm3.h
  group resources
    ../../../resources/iar/: at91sam3u-ek-flash.mac at91sam3u-ek-psram.mac at91sam3u-ek-sram.mac
