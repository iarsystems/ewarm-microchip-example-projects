# IAR project at91sam3u-ek.ewp, settings and files
configuration at91sam3u4_sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U4E Microchip ATSAM3U4E
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: at91sam3u4; sram; TRACE_LEVEL=3; usb_CDCHID
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib/usb/device; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam3u-ek
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam3u4; sram; TRACE_LEVEL=3
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam3u-ek
  OBJCOPY.OOCOutputFile: at91sam3u4_sram.bin
  ILINK.IlinkOutputFile: at91sam3u4_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam3u-ek/at91sam3u4/sram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam3u4_flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam3u4; flash; TRACE_LEVEL=3; usb_CDCHID
  AARM.ADefines: at91sam3u4; flash; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam3u4_flash.bin
  ILINK.IlinkOutputFile: at91sam3u4_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam3u-ek/at91sam3u4/flash
  group .
    ../../: usb-device-composite-cdchid-project
  group at91lib/boards/at91sam3u-ek
    ../../../at91lib/boards/at91sam3u-ek/: board.h board_cstartup_iar.c board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h exceptions.c exceptions.h
  group at91lib/boards/at91sam3u-ek/at91sam3u4
    ../../../at91lib/boards/at91sam3u-ek/at91sam3u4/: AT91SAM3U4.h chip.h flash.icf psram.icf sram.icf
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: irq.h nvic.c
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pit
    ../../../at91lib/peripherals/pit/: pit.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/systick
    ../../../at91lib/peripherals/systick/: systick.c systick.h
  group at91lib/peripherals/tc
    ../../../at91lib/peripherals/tc/: tc.h
  group at91lib/peripherals/usart
    ../../../at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/usb/common/cdc
    ../../../at91lib/usb/common/cdc/: CDCAbstractControlManagementDescriptor.h CDCCallManagementDescriptor.h CDCCommunicationInterfaceDescriptor.h CDCDataInterfaceDescriptor.h CDCDeviceDescriptor.h CDCGenericDescriptor.h CDCGenericRequest.h CDCHeaderDescriptor.h CDCLineCoding.c CDCLineCoding.h CDCSetControlLineStateRequest.c CDCSetControlLineStateRequest.h CDCUnionDescriptor.h
  group at91lib/usb/common/core
    ../../../at91lib/usb/common/core/: USBConfigurationDescriptor.c USBConfigurationDescriptor.h USBDeviceDescriptor.h USBDeviceQualifierDescriptor.h USBEndpointDescriptor.c USBEndpointDescriptor.h USBFeatureRequest.c USBFeatureRequest.h USBGenericDescriptor.c USBGenericDescriptor.h USBGenericRequest.c USBGenericRequest.h USBGetDescriptorRequest.c USBGetDescriptorRequest.h USBInterfaceAssociationDescriptor.h USBInterfaceDescriptor.h USBInterfaceRequest.c USBInterfaceRequest.h USBSetAddressRequest.c USBSetAddressRequest.h USBSetConfigurationRequest.c USBSetConfigurationRequest.h USBStringDescriptor.h
  group at91lib/usb/common/hid
    ../../../at91lib/usb/common/hid/: HIDDescriptor.h HIDDeviceDescriptor.h HIDGenericDescriptor.h HIDGenericDesktop.h HIDGenericRequest.h HIDIdleRequest.c HIDIdleRequest.h HIDInterfaceDescriptor.h HIDKeypad.c HIDKeypad.h HIDLeds.h HIDReport.h HIDReportRequest.c HIDReportRequest.h
  group at91lib/usb/device/composite
    ../../../at91lib/usb/device/composite/: CDCDFunctionDriver.c CDCDFunctionDriver.h CDCDFunctionDriverDescriptors.h CDCHIDDDriver.c CDCHIDDDriver.h CDCHIDDDriverDescriptors.c CDCHIDDDriverDescriptors.h HIDDFunctionDriver.c HIDDFunctionDriver.h HIDDFunctionDriverDescriptors.c HIDDFunctionDriverDescriptors.h
  group at91lib/usb/device/core
    ../../../at91lib/usb/device/core/: USBD.h USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c USBDCallbacks.h USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDDriver.c USBDDriver.h USBDDriverCallbacks.h USBDDriverCb_IfSettingChanged.c USBDDriverDescriptors.h
  group at91lib/usb/device/hid-keyboard
    ../../../at91lib/usb/device/hid-keyboard/: HIDDKeyboardCallbacks.h HIDDKeyboardDriver.h HIDDKeyboardDriverDescriptors.h HIDDKeyboardInputReport.c HIDDKeyboardInputReport.h HIDDKeyboardOutputReport.c HIDDKeyboardOutputReport.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h led.c led.h trace.c trace.h
  group documentation
    ../../../: flashloaders.html
    ../../../documentation/: index.html
  group external_libs/cmsis
    ../../../external_libs/cmsis/: core_cm3.c core_cm3.h
  group resources
    ../../../resources/iar/: at91sam3u-ek-flash.mac at91sam3u-ek-psram.mac at91sam3u-ek-sram.mac
  group usb-device-composite-cdchid-project
    ../: main.c
