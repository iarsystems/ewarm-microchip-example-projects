# IAR project Interrupt.ewp, settings and files
configuration RAM_Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM7A1 Microchip AT91SAM7A1
  ICCARM.CCIncludePath2: srciar\; ..\..\include\; ..\..\include\CSP\Include\; ..\..\include\BSP\Include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: RAM_DEBUG
  AARM.AUserIncludes: ..\..\include\
  ILINK.IlinkOutputFile: Interrupt.out
  ILINK.IlinkIcfFile: resource/at91SAM7A1_EKRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_debug (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: Flash_DEBUG
  ILINK.IlinkIcfFile: resource/at91SAM7A1_FALSH.icf
configuration bin (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.ADefines: Flash_DEBUG
  OBJCOPY.OOCOutputFile: Interrupt.hex
  ILINK.IlinkIcfFile: resource/at91SAM7A1_FALSH.icf
  group Cstartup
    SrcIAR/: Cstartup.s Cstartup_SAM7.c
  group Interrupt
    ../src/: main.c
    SrcIAR/: swirq0_handler.s
  group xRessource
    resource/: at91SAM7A1_EKRAM.icf at91SAM7A1_FALSH.icf SAM7A1_RAM.mac
