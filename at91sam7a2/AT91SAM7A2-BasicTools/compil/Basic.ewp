# IAR project Basic.ewp, settings and files
configuration RAM_Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM7A2 Microchip AT91SAM7A2
  ICCARM.CCIncludePath2: srciar\; ..\..\include\; ..\..\include\CSP\Include\; ..\..\include\BSP\Include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: RAM_DEBUG
  AARM.AUserIncludes: ..\..\include\
  ILINK.IlinkOutputFile: Basic.out
  ILINK.IlinkIcfFile: resource/at91SAM7A2_EKRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_debug (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: Flash_DEBUG
  ILINK.IlinkIcfFile: resource/at91SAM7A2_FALSH.icf
configuration Bin (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.ADefines: Flash_DEBUG
  OBJCOPY.OOCOutputFile: Basic.hex
  ILINK.IlinkIcfFile: resource/at91SAM7A2_FALSH.icf
  group Basic
    ../src/: bsp_lcd.c main.c
  group Cstartup
    SrcIAR/: Cstartup.s Cstartup_SAM7.c
  group xRessource
    resource/: at91SAM7A2_EKRAM.icf at91SAM7A2_FALSH.icf SAM7A2_RAM.mac
