<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Interrupt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Interrupt</project>
        <configuration>bin</configuration>
      </member>
      <member>
        <project>Interrupt</project>
        <configuration>Flash_debug</configuration>
      </member>
      <member>
        <project>Interrupt</project>
        <configuration>RAM_Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
