# IAR project at91sam7a3-ek.ewp, settings and files
configuration at91sam7a3_flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7a3 Microchip at91sam7a3
  ICCARM.CCDefines: at91sam7a3; flash; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam7a3-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7a3; flash; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7a3-ek
  OBJCOPY.OOCOutputFile: at91sam7a3_flash.bin
  ILINK.IlinkOutputFile: at91sam7a3_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7a3-ek/at91sam7a3/flash.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7a3_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7a3; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7a3; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7a3_sram.bin
  ILINK.IlinkOutputFile: at91sam7a3_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7a3-ek/at91sam7a3/sram.icf
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam7a3-ek
    ../../../at91lib/boards/at91sam7a3-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam7a3-ek/at91sam7a3
    ../../../at91lib/boards/at91sam7a3-ek/at91sam7a3/: AT91SAM7A3.h chip.h flash.icf sram.icf
  group at91lib/components/iso7816
    ../../../at91lib/components/iso7816/: iso7816_4.c iso7816_4.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pit
    ../../../at91lib/peripherals/pit/: pit.c pit.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/usart
    ../../../at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h led.c led.h math.c math.h trace.c trace.h
  group basic-iso7816-project
    ../../../at91sam7a3-ek/basic-iso7816-project/: main.c
  group resources
    ../../../resources/iar/: at91sam7a3-ek-flash.mac at91sam7a3-ek-sram.mac
