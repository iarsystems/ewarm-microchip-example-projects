<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
	<project>
		<path>$WS_DIR$/ewp/at91sam7a3-ek.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>All</name>&gt;
			<member>
				<project>at91sam7a3-ek</project>
				<configuration>at91sam7a3_flash</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
