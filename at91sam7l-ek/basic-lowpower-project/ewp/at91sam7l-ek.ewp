# IAR project at91sam7l-ek.ewp, settings and files
configuration at91sam7l128_flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7l128 Microchip at91sam7l128
  ICCARM.CCDefines: at91sam7l128; flash; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam7l-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7l128; flash; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7l-ek
  OBJCOPY.OOCOutputFile: at91sam7l128_flash.bin
  ILINK.IlinkOutputFile: at91sam7l128_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7l-ek/at91sam7l128/flash.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7l64_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7l64 Microchip at91sam7l64
  ICCARM.CCDefines: at91sam7l64; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7l64; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7l64_flash.bin
  ILINK.IlinkOutputFile: at91sam7l64_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7l-ek/at91sam7l64/flash.icf
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam7l-ek
    ../../../at91lib/boards/at91sam7l-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam7l-ek/at91sam7l128
    ../../../at91lib/boards/at91sam7l-ek/at91sam7l128/: AT91SAM7L128.h chip.h flash.icf
  group at91lib/boards/at91sam7l-ek/at91sam7l64
    ../../../at91lib/boards/at91sam7l-ek/at91sam7l64/: AT91SAM7L64.h chip.h flash.icf
  group at91lib/components/kbmatrix
    ../../../at91lib/components/kbmatrix/: kbmatrix.c kbmatrix.h
  group at91lib/components/slcd/s7leklcd
    ../../../at91lib/components/slcd/s7leklcd/: s7leklcd.c s7leklcd.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/rtc
    ../../../at91lib/peripherals/rtc/: rtc.c rtc.h
  group at91lib/peripherals/slcdc
    ../../../at91lib/peripherals/slcdc/: slcdc.c slcdc.h
  group at91lib/peripherals/supc
    ../../../at91lib/peripherals/supc/: supc.c supc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h led.c led.h trace.c trace.h
  group basic-lowpower-project
    ../../../at91sam7l-ek/basic-lowpower-project/: main.c
  group resources
    ../../../resources/iar/: at91sam7l-ek-flash.mac at91sam7l-ek-sram.mac
