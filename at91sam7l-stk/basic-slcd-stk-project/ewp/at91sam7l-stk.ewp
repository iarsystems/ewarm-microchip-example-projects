# IAR project at91sam7l-stk.ewp, settings and files
configuration at91sam7l128_flash (ARM, debug)
  General.OGChipSelectEditMenu: at91sam7l128 Microchip at91sam7l128
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: at91sam7l128; flash; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam7l-stk
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam7l128; flash; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7l-stk
  OBJCOPY.OOCOutputFile: at91sam7l128_flash.bin
  ILINK.IlinkOutputFile: at91sam7l128_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7l-stk/at91sam7l128/flash
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7l64_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7l64 Microchip at91sam7l64
  ICCARM.CCDefines: at91sam7l64; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7l64; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7l64_flash.bin
  ILINK.IlinkOutputFile: at91sam7l64_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7l-stk/at91sam7l64/flash
  group at91lib/boards/at91sam7l-stk
    ../../../at91lib/boards/at91sam7l-stk/: board.h board_cstartup_iar.s board_memories.c board_memories.h
  group at91lib/boards/at91sam7l-stk/at91sam7l128
    ../../../at91lib/boards/at91sam7l-stk/at91sam7l128/: AT91SAM7L128.h chip.h flash.icf
  group at91lib/boards/at91sam7l-stk/at91sam7l64
    ../../../at91lib/boards/at91sam7l-stk/at91sam7l64/: AT91SAM7L64.h chip.h flash.icf
  group at91lib/components/slcd/s7lstklcd
    ../../../at91lib/components/slcd/s7lstklcd/: font.h font1.c s7lstklcd.c s7lstklcd.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pit
    ../../../at91lib/peripherals/pit/: pit.c pit.h
  group at91lib/peripherals/slcdc
    ../../../at91lib/peripherals/slcdc/: slcdc.c slcdc.h
  group at91lib/peripherals/supc
    ../../../at91lib/peripherals/supc/: supc.c supc.h
  group at91lib/peripherals/tc
    ../../../at91lib/peripherals/tc/: tc.c tc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group basic-slcd-stk-project
    ../: lowlevel.c main.c
  group documentation
    ../../../: flashloaders.html
    ../../../documentation/: index.html
  group resources
    ../../../resources/iar/: at91sam7l-stk-flash.mac at91sam7l-stk-sram.mac
