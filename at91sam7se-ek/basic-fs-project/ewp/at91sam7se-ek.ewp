# IAR project at91sam7se-ek.ewp, settings and files
configuration at91sam7se256_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7se256 Microchip at91sam7se256
  ICCARM.CCDefines: at91sam7se256; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91sam7se-ek\basic-fs-project; ..\..\..\at91lib; ..\..\..\at91lib/peripherals; ..\..\..\external_libs/fat; ..\..\..\at91lib/memories; ..\..\..\external_libs/fat/fatfs; ..\..\..\external_libs/fat/fatfs/src; ..\..\..\external_libs/fat/efsl; ..\..\..\external_libs/fat/efsl/src; ..\..\..\external_libs/fat/efsl/inc; ..\..\..\external_libs/fat/efsl/conf; ..\..\..\external_libs/fat/efsl/src/interfaces; ..\..\..\external_libs/fat/efsl/inc/interfaces; ..\..\..\at91lib/boards/at91sam7se-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7se256; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7se-ek
  OBJCOPY.OOCOutputFile: at91sam7se256_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se256_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7se256_flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7se256; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se256; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se256_flash.bin
  ILINK.IlinkOutputFile: at91sam7se256_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/flash
configuration at91sam7se32_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se32 Microchip at91sam7se32
  ICCARM.CCDefines: at91sam7se32; sdram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se32; sdram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se32_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se32_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/sdram
configuration at91sam7se512_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Microchip at91sam7se512
  ICCARM.CCDefines: at91sam7se512; sdram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se512; sdram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se512_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se512_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/sdram
configuration at91sam7se512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Microchip at91sam7se512
  ICCARM.CCDefines: at91sam7se512; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se512; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se512_flash.bin
  ILINK.IlinkOutputFile: at91sam7se512_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/flash
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group .
    ../../../at91sam7se-ek/: basic-fs-project
  group at91lib/boards/at91sam7se-ek
    ../../../at91lib/boards/at91sam7se-ek/: board.h board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam7se-ek/at91sam7se256
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/: AT91SAM7SE256.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/boards/at91sam7se-ek/at91sam7se32
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/: AT91SAM7SE32.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/boards/at91sam7se-ek/at91sam7se512
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/: AT91SAM7SE512.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/memories
    ../../../at91lib/memories/: MEDDdram.c MEDDdram.h MEDFlash.h MEDSdram.c MEDSdram.h Media.c Media.h
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pit
    ../../../at91lib/peripherals/pit/: pit.c pit.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15_asm_iar.s
  group at91lib/usb/common/core
    ../../../at91lib/usb/common/core/: USBConfigurationDescriptor.c USBConfigurationDescriptor.h USBDeviceDescriptor.h USBDeviceQualifierDescriptor.h USBEndpointDescriptor.c USBEndpointDescriptor.h USBFeatureRequest.c USBFeatureRequest.h USBGenericDescriptor.c USBGenericDescriptor.h USBGenericRequest.c USBGenericRequest.h USBGetDescriptorRequest.c USBGetDescriptorRequest.h USBInterfaceDescriptor.h USBInterfaceRequest.c USBInterfaceRequest.h USBSetAddressRequest.c USBSetAddressRequest.h USBSetConfigurationRequest.c USBSetConfigurationRequest.h USBStringDescriptor.h
  group at91lib/usb/common/massstorage
    ../../../at91lib/usb/common/massstorage/: MSDeviceDescriptor.h MSInterfaceDescriptor.h
  group at91lib/usb/device/core
    ../../../at91lib/usb/device/core/: USBD.h USBDCallbacks.h USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c USBDDriver.c USBDDriver.h USBDDriverCallbacks.h USBDDriverCb_IfSettingChanged.c USBDDriverDescriptors.h USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c
  group at91lib/usb/device/massstorage
    ../../../at91lib/usb/device/massstorage/: MSD.h MSDDStateMachine.c MSDDStateMachine.h MSDDriver.c MSDDriver.h MSDDriverDescriptors.c MSDDriverDescriptors.h MSDIOFifo.h MSDLun.c MSDLun.h SBC.h SBCMethods.c SBCMethods.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h led.c led.h math.c math.h trace.c trace.h
  group external_libs/fat/efsl/conf
    ../../../external_libs/fat/efsl/conf/: config.h
  group external_libs/fat/efsl/inc
    ../../../external_libs/fat/efsl/inc/: debug.h dir.h disc.h efs.h error.h extract.h fat.h file.h fs.h interface.h debug.h types.h ioman.h ls.h mkfs.h partition.h plibc.h time.h types.h ui.h
  group external_libs/fat/efsl/inc/interfaces
    ../../../external_libs/fat/efsl/inc/interfaces/: at91sam7s_spi.h at91sam_media.h
  group external_libs/fat/efsl/src
    ../../../external_libs/fat/efsl/src/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group external_libs/fat/efsl/src/interfaces
    ../../../external_libs/fat/efsl/src/interfaces/: at91sam_media.c
  group external_libs/fat/fatfs/src
    ../../../external_libs/fat/fatfs/src/: diskio.c diskio.h ff.c ff.h ff_util.c ff_util.h integer.h tff.c
  group basic-fs-project
    ../../../at91sam7se-ek/basic-fs-project/: fatfs_config.h main.c
  group resources
    ../../../resources/iar/: at91sam7se-ek-sdram.mac at91sam7se-ek-flash.mac at91sam7se-ek-sram.mac
