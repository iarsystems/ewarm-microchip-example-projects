# IAR project at91sam7se-ek.ewp, settings and files
configuration at91sam7se256_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7se256 Microchip at91sam7se256
  ICCARM.CCDefines: at91sam7se256; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/memories; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam7se-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7se256; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7se-ek
  OBJCOPY.OOCOutputFile: at91sam7se256_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se256_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/sdram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7se256_flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7se256; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se256; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se256_flash.bin
  ILINK.IlinkOutputFile: at91sam7se256_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/flash.icf
configuration at91sam7se256_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7se256; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se256; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se256_sram.bin
  ILINK.IlinkOutputFile: at91sam7se256_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/sram.icf
configuration at91sam7se32_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se32 Microchip at91sam7se32
  ICCARM.CCDefines: at91sam7se32; sdram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se32; sdram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se32_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se32_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/sdram.icf
configuration at91sam7se32_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se32 Microchip at91sam7se32
  ICCARM.CCDefines: at91sam7se32; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se32; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se32_flash.bin
  ILINK.IlinkOutputFile: at91sam7se32_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/flash.icf
configuration at91sam7se512_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Microchip at91sam7se512
  ICCARM.CCDefines: at91sam7se512; sdram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se512; sdram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se512_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se512_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/sdram.icf
configuration at91sam7se512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Microchip at91sam7se512
  ICCARM.CCDefines: at91sam7se512; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se512; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se512_flash.bin
  ILINK.IlinkOutputFile: at91sam7se512_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/flash.icf
configuration at91sam7se512_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Microchip at91sam7se512
  ICCARM.CCDefines: at91sam7se512; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se512; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se512_sram.bin
  ILINK.IlinkOutputFile: at91sam7se512_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/sram.icf
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam7se-ek
    ../../../at91lib/boards/at91sam7se-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam7se-ek/at91sam7se256
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/: AT91SAM7SE256.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/boards/at91sam7se-ek/at91sam7se32
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/: AT91SAM7SE32.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/boards/at91sam7se-ek/at91sam7se512
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/: AT91SAM7SE512.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/memories/nandflash
    ../../../at91lib/memories/nandflash/: EccNandFlash.c EccNandFlash.h NandCommon.h NandFlashModel.c NandFlashModel.h NandFlashModelList.c NandFlashModelList.h NandSpareScheme.c NandSpareScheme.h RawNandFlash.c RawNandFlash.h SkipBlockNandFlash.c SkipBlockNandFlash.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h hamming.c hamming.h math.c math.h trace.c trace.h
  group basic-nandflash-project
    ../../../at91sam7se-ek/basic-nandflash-project/: main.c
  group resources
    ../../../resources/iar/: at91sam7se-ek-sdram.mac at91sam7se-ek-flash.mac at91sam7se-ek-sram.mac
