# IAR project at91sam7se-ek.ewp, settings and files
configuration at91sam7se256_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7se256 Microchip at91sam7se256
  ICCARM.CCDefines: at91sam7se256; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/memories; ..\..\..\at91lib; ..\..\..\at91lib/boards/at91sam7se-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7se256; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7se-ek
  OBJCOPY.OOCOutputFile: at91sam7se256_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se256_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7se32_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se32 Microchip at91sam7se32
  ICCARM.CCDefines: at91sam7se32; sdram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se32; sdram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se32_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se32_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/sdram
configuration at91sam7se512_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Microchip at91sam7se512
  ICCARM.CCDefines: at91sam7se512; sdram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se512; sdram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se512_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se512_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/sdram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam7se-ek
    ../../../at91lib/boards/at91sam7se-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam7se-ek/at91sam7se256
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/: AT91SAM7SE256.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/boards/at91sam7se-ek/at91sam7se32
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/: AT91SAM7SE32.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/boards/at91sam7se-ek/at91sam7se512
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/: AT91SAM7SE512.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/memories/norflash
    ../../../at91lib/memories/norflash/: NorFlashAmd.c NorFlashAmd.h NorFlashApi.c NorFlashApi.h NorFlashCFI.c NorFlashCFI.h NorFlashCommon.c NorFlashCommon.h NorFlashIntel.c NorFlashIntel.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h math.c math.h trace.c trace.h
  group basic-norflash-project
    ../../../at91sam7se-ek/basic-norflash-project/: main.c
  group resources
    ../../../resources/iar/: at91sam7se-ek-sdram.mac at91sam7se-ek-flash.mac at91sam7se-ek-sram.mac
