# IAR project at91sam7se-ek.ewp, settings and files
configuration at91sam7se256_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7se256 Microchip at91sam7se256
  ICCARM.CCDefines: at91sam7se256; sdram; TRACE_LEVEL=3
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam7se-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7se256; sdram; TRACE_LEVEL=3
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7se-ek
  OBJCOPY.OOCOutputFile: at91sam7se256_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se256_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/sdram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7se256_flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7se256; flash; TRACE_LEVEL=3
  AARM.ADefines: at91sam7se256; flash; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7se256_flash.bin
  ILINK.IlinkOutputFile: at91sam7se256_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/flash.icf
configuration at91sam7se256_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7se256; sram; TRACE_LEVEL=3
  AARM.ADefines: at91sam7se256; sram; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7se256_sram.bin
  ILINK.IlinkOutputFile: at91sam7se256_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/sram.icf
configuration at91sam7se32_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se32 Microchip at91sam7se32
  ICCARM.CCDefines: at91sam7se32; sdram; TRACE_LEVEL=3
  AARM.ADefines: at91sam7se32; sdram; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7se32_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se32_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/sdram.icf
configuration at91sam7se32_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se32 Microchip at91sam7se32
  ICCARM.CCDefines: at91sam7se32; flash; TRACE_LEVEL=3
  AARM.ADefines: at91sam7se32; flash; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7se32_flash.bin
  ILINK.IlinkOutputFile: at91sam7se32_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/flash.icf
configuration at91sam7se512_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Microchip at91sam7se512
  ICCARM.CCDefines: at91sam7se512; sdram; TRACE_LEVEL=3
  AARM.ADefines: at91sam7se512; sdram; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7se512_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se512_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/sdram.icf
configuration at91sam7se512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Microchip at91sam7se512
  ICCARM.CCDefines: at91sam7se512; flash; TRACE_LEVEL=3
  AARM.ADefines: at91sam7se512; flash; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7se512_flash.bin
  ILINK.IlinkOutputFile: at91sam7se512_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/flash.icf
configuration at91sam7se512_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Microchip at91sam7se512
  ICCARM.CCDefines: at91sam7se512; sram; TRACE_LEVEL=3
  AARM.ADefines: at91sam7se512; sram; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7se512_sram.bin
  ILINK.IlinkOutputFile: at91sam7se512_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/sram.icf
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group .
    ../../../at91sam7se-ek/: usb-device-hid-keyboard-project
  group at91lib/boards/at91sam7se-ek
    ../../../at91lib/boards/at91sam7se-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam7se-ek/at91sam7se256
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/: AT91SAM7SE256.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/boards/at91sam7se-ek/at91sam7se32
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/: AT91SAM7SE32.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/boards/at91sam7se-ek/at91sam7se512
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/: AT91SAM7SE512.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pit
    ../../../at91lib/peripherals/pit/: pit.c pit.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/usb/common/core
    ../../../at91lib/usb/common/core/: USBConfigurationDescriptor.c USBConfigurationDescriptor.h USBDeviceDescriptor.h USBDeviceQualifierDescriptor.h USBEndpointDescriptor.c USBEndpointDescriptor.h USBFeatureRequest.c USBFeatureRequest.h USBGenericDescriptor.c USBGenericDescriptor.h USBGenericRequest.c USBGenericRequest.h USBGetDescriptorRequest.c USBGetDescriptorRequest.h USBInterfaceDescriptor.h USBInterfaceRequest.c USBInterfaceRequest.h USBSetAddressRequest.c USBSetAddressRequest.h USBSetConfigurationRequest.c USBSetConfigurationRequest.h USBStringDescriptor.h
  group at91lib/usb/common/hid
    ../../../at91lib/usb/common/hid/: HIDDescriptor.h HIDDeviceDescriptor.h HIDGenericDescriptor.h HIDGenericDesktop.h HIDGenericRequest.h HIDIdleRequest.c HIDIdleRequest.h HIDInterfaceDescriptor.h HIDKeypad.c HIDKeypad.h HIDLeds.h HIDReport.h HIDReportRequest.c HIDReportRequest.h
  group at91lib/usb/device/core
    ../../../at91lib/usb/device/core/: USBD.h USBDCallbacks.h USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDDriver.c USBDDriver.h USBDDriverCallbacks.h USBDDriverCb_IfSettingChanged.c USBDDriverDescriptors.h USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c
  group at91lib/usb/device/hid-keyboard
    ../../../at91lib/usb/device/hid-keyboard/: HIDDKeyboardCallbacks.h HIDDKeyboardDriver.c HIDDKeyboardDriver.h HIDDKeyboardDriverDescriptors.c HIDDKeyboardDriverDescriptors.h HIDDKeyboardInputReport.c HIDDKeyboardInputReport.h HIDDKeyboardOutputReport.c HIDDKeyboardOutputReport.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h led.c led.h trace.c trace.h
  group usb-device-hid-keyboard-project
    ../../../at91sam7se-ek/usb-device-hid-keyboard-project/: main.c
  group resources
    ../../../resources/iar/: at91sam7se-ek-sdram.mac at91sam7se-ek-flash.mac at91sam7se-ek-sram.mac
