<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
	<project>
		<path>$WS_DIR$/ewp/at91sam7x-ek.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>All</name>&gt;
			<member>
				<project>at91sam7x-ek</project>
				<configuration>at91sam7x128_flash</configuration>
			</member>
			<member>
				<project>at91sam7x-ek</project>
				<configuration>at91sam7x256_flash</configuration>
			</member>
			<member>
				<project>at91sam7x-ek</project>
				<configuration>at91sam7x256_sram</configuration>
			</member>
			<member>
				<project>at91sam7x-ek</project>
				<configuration>at91sam7x512_flash</configuration>
			</member>
			<member>
				<project>at91sam7x-ek</project>
				<configuration>at91sam7x512_sram</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
