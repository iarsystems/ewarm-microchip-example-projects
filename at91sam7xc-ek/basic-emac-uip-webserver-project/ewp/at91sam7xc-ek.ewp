# IAR project at91sam7xc-ek.ewp, settings and files
configuration at91sam7xc128_flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7xc128 Microchip at91sam7xc128
  ICCARM.CCDefines: at91sam7xc128; flash; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/drivers; ..\..\..\at91lib; ..\..\..\at91sam7xc-ek\basic-emac-uip-webserver-project; ..\..\..\external_libs; ..\..\..\at91lib/utility; ..\..\..\external_libs/ethernet/uip/uip; ..\..\..\external_libs/ethernet/uip/lib; ..\..\..\external_libs/ethernet/uip/apps/dhcpc; ..\..\..\external_libs/ethernet/uip/apps/webserver; ..\..\..\at91lib/boards/at91sam7xc-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7xc128; flash; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7xc-ek
  OBJCOPY.OOCOutputFile: at91sam7xc128_flash.bin
  ILINK.IlinkOutputFile: at91sam7xc128_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc128/flash
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7xc256_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc256 Microchip at91sam7xc256
  ICCARM.CCDefines: at91sam7xc256; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7xc256; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7xc256_flash.bin
  ILINK.IlinkOutputFile: at91sam7xc256_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc256/flash
configuration at91sam7xc256_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc256 Microchip at91sam7xc256
  ICCARM.CCDefines: at91sam7xc256; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7xc256; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7xc256_sram.bin
  ILINK.IlinkOutputFile: at91sam7xc256_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc256/sram
configuration at91sam7xc512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc512 Microchip at91sam7xc512
  ICCARM.CCDefines: at91sam7xc512; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7xc512; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7xc512_flash.bin
  ILINK.IlinkOutputFile: at91sam7xc512_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc512/flash
configuration at91sam7xc512_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc512 Microchip at91sam7xc512
  ICCARM.CCDefines: at91sam7xc512; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7xc512; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7xc512_sram.bin
  ILINK.IlinkOutputFile: at91sam7xc512_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc512/sram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group .
    ../../../at91sam7xc-ek/: basic-emac-uip-webserver-project
  group at91lib/boards/at91sam7xc-ek
    ../../../at91lib/boards/at91sam7xc-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam7xc-ek/at91sam7xc128
    ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc128/: AT91SAM7XC128.h chip.h flash.icf sram.icf
  group at91lib/boards/at91sam7xc-ek/at91sam7xc256
    ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc256/: AT91SAM7XC256.h chip.h flash.icf sram.icf
  group at91lib/boards/at91sam7xc-ek/at91sam7xc512
    ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc512/: AT91SAM7XC512.h chip.h flash.icf sram.icf
  group at91lib/drivers/macb
    ../../../at91lib/drivers/macb/: macb.c macb.h mii.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/emac
    ../../../at91lib/peripherals/emac/: emac.c emac.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/rstc
    ../../../at91lib/peripherals/rstc/: rstc.c rstc.h
  group at91lib/peripherals/tc
    ../../../at91lib/peripherals/tc/: tc.c tc.h
  group at91lib/peripherals/usart
    ../../../at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group external_libs/ethernet/uip/apps/dhcpc
    ../../../external_libs/ethernet/uip/apps/dhcpc/: dhcpc.c dhcpc.h
  group external_libs/ethernet/uip/apps/webserver
    ../../../external_libs/ethernet/uip/apps/webserver/: http-strings.c http-strings.h httpd-cgi.c httpd-cgi.h httpd-fs.c httpd-fs.h httpd-fsdata.c httpd-fsdata.h httpd.c httpd.h webserver.h
  group external_libs/ethernet/uip/lib
    ../../../external_libs/ethernet/uip/lib/: memb.c memb.h
  group external_libs/ethernet/uip/uip
    ../../../external_libs/ethernet/uip/uip/: clock.h lc-switch.h lc.h psock.c psock.h pt.h timer.c timer.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uipopt.h
  group basic-emac-uip-webserver-project
    ../../../at91sam7xc-ek/basic-emac-uip-webserver-project/: clock-arch.c clock-arch.h main.c tapdev.c tapdev.h uip-conf.h
  group resources
    ../../../resources/iar/: at91sam7xc-ek-flash.mac at91sam7xc-ek-sram.mac
