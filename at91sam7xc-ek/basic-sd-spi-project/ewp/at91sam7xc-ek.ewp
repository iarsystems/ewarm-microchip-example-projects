# IAR project at91sam7xc-ek.ewp, settings and files
configuration at91sam7xc128_flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7xc128 Microchip at91sam7xc128
  ICCARM.CCDefines: at91sam7xc128; flash; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/memories; ..\..\..\at91lib; ..\..\..\external_libs/crc; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam7xc-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7xc128; flash; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7xc-ek
  OBJCOPY.OOCOutputFile: at91sam7xc128_flash.bin
  ILINK.IlinkOutputFile: at91sam7xc128_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc128/flash
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7xc128_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7xc128; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7xc128; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7xc128_sram.bin
  ILINK.IlinkOutputFile: at91sam7xc128_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc128/sram
configuration at91sam7xc256_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc256 Microchip at91sam7xc256
  ICCARM.CCDefines: at91sam7xc256; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7xc256; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7xc256_flash.bin
  ILINK.IlinkOutputFile: at91sam7xc256_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc256/flash
configuration at91sam7xc256_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc256 Microchip at91sam7xc256
  ICCARM.CCDefines: at91sam7xc256; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7xc256; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7xc256_sram.bin
  ILINK.IlinkOutputFile: at91sam7xc256_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc256/sram
configuration at91sam7xc512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc512 Microchip at91sam7xc512
  ICCARM.CCDefines: at91sam7xc512; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7xc512; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7xc512_flash.bin
  ILINK.IlinkOutputFile: at91sam7xc512_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc512/flash
configuration at91sam7xc512_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc512 Microchip at91sam7xc512
  ICCARM.CCDefines: at91sam7xc512; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7xc512; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7xc512_sram.bin
  ILINK.IlinkOutputFile: at91sam7xc512_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc512/sram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam7xc-ek
    ../../../at91lib/boards/at91sam7xc-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam7xc-ek/at91sam7xc128
    ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc128/: AT91SAM7XC128.h chip.h flash.icf sram.icf
  group at91lib/boards/at91sam7xc-ek/at91sam7xc256
    ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc256/: AT91SAM7XC256.h chip.h flash.icf sram.icf
  group at91lib/boards/at91sam7xc-ek/at91sam7xc512
    ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc512/: AT91SAM7XC512.h chip.h flash.icf sram.icf
  group at91lib/memories/sdmmc
    ../../../at91lib/memories/sdmmc/: sdmmc_spi.c sdmmc_spi.h sdspi.c sdspi.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/spi
    ../../../at91lib/peripherals/spi/: spi.c spi.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group external_libs/crc
    ../../../external_libs/crc/: crc-ccitt.c crc-ccitt.h crc-itu-t.c crc-itu-t.h crc16.c crc16.h crc7.c crc7.h linuxtypes.h
  group basic-sd-spi-project
    ../../../at91sam7xc-ek/basic-sd-spi-project/: main.c
  group resources
    ../../../resources/iar/: at91sam7xc-ek-flash.mac at91sam7xc-ek-sram.mac
