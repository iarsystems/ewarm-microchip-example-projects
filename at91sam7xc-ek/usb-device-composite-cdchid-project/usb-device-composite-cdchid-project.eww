<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
	<project>
		<path>$WS_DIR$/ewp/at91sam7xc-ek.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>All</name>&gt;
			<member>
				<project>at91sam7xc-ek</project>
				<configuration>at91sam7xc128_flash</configuration>
			</member>
			<member>
				<project>at91sam7xc-ek</project>
				<configuration>at91sam7xc128_sram</configuration>
			</member>
			<member>
				<project>at91sam7xc-ek</project>
				<configuration>at91sam7xc256_flash</configuration>
			</member>
			<member>
				<project>at91sam7xc-ek</project>
				<configuration>at91sam7xc256_sram</configuration>
			</member>
			<member>
				<project>at91sam7xc-ek</project>
				<configuration>at91sam7xc512_flash</configuration>
			</member>
			<member>
				<project>at91sam7xc-ek</project>
				<configuration>at91sam7xc512_sram</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
