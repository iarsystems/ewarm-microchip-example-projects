# IAR project at91sam7xc-ek.ewp, settings and files
configuration at91sam7xc128_flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7xc128 Microchip at91sam7xc128
  ICCARM.CCDefines: at91sam7xc128; flash; TRACE_LEVEL=3; usb_HIDMSD
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib/usb/device; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam7xc-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7xc128; flash; TRACE_LEVEL=3
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7xc-ek
  OBJCOPY.OOCOutputFile: at91sam7xc128_flash.bin
  ILINK.IlinkOutputFile: at91sam7xc128_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc128/flash
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7xc256_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc256 Microchip at91sam7xc256
  ICCARM.CCDefines: at91sam7xc256; flash; TRACE_LEVEL=3; usb_HIDMSD
  AARM.ADefines: at91sam7xc256; flash; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7xc256_flash.bin
  ILINK.IlinkOutputFile: at91sam7xc256_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc256/flash
configuration at91sam7xc256_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc256 Microchip at91sam7xc256
  ICCARM.CCDefines: at91sam7xc256; sram; TRACE_LEVEL=3; usb_HIDMSD
  AARM.ADefines: at91sam7xc256; sram; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7xc256_sram.bin
  ILINK.IlinkOutputFile: at91sam7xc256_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc256/sram
configuration at91sam7xc512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc512 Microchip at91sam7xc512
  ICCARM.CCDefines: at91sam7xc512; flash; TRACE_LEVEL=3; usb_HIDMSD
  AARM.ADefines: at91sam7xc512; flash; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7xc512_flash.bin
  ILINK.IlinkOutputFile: at91sam7xc512_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc512/flash
configuration at91sam7xc512_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7xc512 Microchip at91sam7xc512
  ICCARM.CCDefines: at91sam7xc512; sram; TRACE_LEVEL=3; usb_HIDMSD
  AARM.ADefines: at91sam7xc512; sram; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7xc512_sram.bin
  ILINK.IlinkOutputFile: at91sam7xc512_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc512/sram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group .
    ../../../at91sam7xc-ek/: usb-device-composite-hidmsd-project
  group at91lib/boards/at91sam7xc-ek
    ../../../at91lib/boards/at91sam7xc-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam7xc-ek/at91sam7xc128
    ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc128/: AT91SAM7XC128.h chip.h flash.icf sram.icf
  group at91lib/boards/at91sam7xc-ek/at91sam7xc256
    ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc256/: AT91SAM7XC256.h chip.h flash.icf sram.icf
  group at91lib/boards/at91sam7xc-ek/at91sam7xc512
    ../../../at91lib/boards/at91sam7xc-ek/at91sam7xc512/: AT91SAM7XC512.h chip.h flash.icf sram.icf
  group at91lib/memories
    ../../../at91lib/memories/: MEDDdram.c MEDDdram.h MEDFlash.c MEDFlash.h MEDSdram.c MEDSdram.h Media.c Media.h
  group at91lib/memories/flash
    ../../../at91lib/memories/flash/: flashd.h flashd_efc.c
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/efc
    ../../../at91lib/peripherals/efc/: efc.c efc.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pit
    ../../../at91lib/peripherals/pit/: pit.c pit.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/usart
    ../../../at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/usb/common/core
    ../../../at91lib/usb/common/core/: USBConfigurationDescriptor.c USBConfigurationDescriptor.h USBDeviceDescriptor.h USBDeviceQualifierDescriptor.h USBEndpointDescriptor.c USBEndpointDescriptor.h USBFeatureRequest.c USBFeatureRequest.h USBGenericDescriptor.c USBGenericDescriptor.h USBGenericRequest.c USBGenericRequest.h USBGetDescriptorRequest.c USBGetDescriptorRequest.h USBInterfaceAssociationDescriptor.h USBInterfaceDescriptor.h USBInterfaceRequest.c USBInterfaceRequest.h USBSetAddressRequest.c USBSetAddressRequest.h USBSetConfigurationRequest.c USBSetConfigurationRequest.h USBStringDescriptor.h
  group at91lib/usb/common/hid
    ../../../at91lib/usb/common/hid/: HIDDescriptor.h HIDDeviceDescriptor.h HIDGenericDescriptor.h HIDGenericDesktop.h HIDGenericRequest.h HIDIdleRequest.c HIDIdleRequest.h HIDInterfaceDescriptor.h HIDKeypad.c HIDKeypad.h HIDLeds.h HIDReport.h HIDReportRequest.c HIDReportRequest.h
  group at91lib/usb/common/massstorage
    ../../../at91lib/usb/common/massstorage/: MSDeviceDescriptor.h MSInterfaceDescriptor.h
  group at91lib/usb/device/composite
    ../../../at91lib/usb/device/composite/: HIDDFunctionDriver.c HIDDFunctionDriver.h HIDDFunctionDriverDescriptors.c HIDDFunctionDriverDescriptors.h HIDMSDDDriver.c HIDMSDDDriver.h HIDMSDDDriverDescriptors.c HIDMSDDDriverDescriptors.h MSDDFunctionDriver.c MSDDFunctionDriver.h MSDDFunctionDriverDescriptors.h
  group at91lib/usb/device/core
    ../../../at91lib/usb/device/core/: USBD.h USBDCallbacks.h USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDDriver.c USBDDriver.h USBDDriverCallbacks.h USBDDriverCb_IfSettingChanged.c USBDDriverDescriptors.h USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c
  group at91lib/usb/device/hid-keyboard
    ../../../at91lib/usb/device/hid-keyboard/: HIDDKeyboardCallbacks.h HIDDKeyboardDriver.h HIDDKeyboardDriverDescriptors.h HIDDKeyboardInputReport.c HIDDKeyboardInputReport.h HIDDKeyboardOutputReport.c HIDDKeyboardOutputReport.h
  group at91lib/usb/device/massstorage
    ../../../at91lib/usb/device/massstorage/: MSD.h MSDDStateMachine.c MSDDStateMachine.h MSDDriver.h MSDIOFifo.h MSDLun.c MSDLun.h SBC.h SBCMethods.c SBCMethods.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h led.c led.h math.c math.h trace.c trace.h
  group usb-device-composite-hidmsd-project
    ../../../at91sam7xc-ek/usb-device-composite-hidmsd-project/: main.c
  group resources
    ../../../resources/iar/: at91sam7xc-ek-flash.mac at91sam7xc-ek-sram.mac
