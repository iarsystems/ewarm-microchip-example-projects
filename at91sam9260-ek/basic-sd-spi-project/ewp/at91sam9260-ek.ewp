# IAR project at91sam9260-ek.ewp, settings and files
configuration at91sam9260_sdram (ARM, debug)
  General.OGChipSelectEditMenu: at91sam9260 Microchip at91sam9260
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: at91sam9260; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/memories; ..\..\..\at91lib; ..\..\..\external_libs/crc; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9260-ek
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam9260; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9260-ek
  OBJCOPY.OOCOutputFile: at91sam9260_sdram.bin
  ILINK.IlinkOutputFile: at91sam9260_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9260-ek/at91sam9260/sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
  group at91lib/boards/at91sam9260-ek
    ../../../at91lib/boards/at91sam9260-ek/: board.h board_cstartup_iar.s board_lowlevel.c board_memories.c board_memories.h
  group at91lib/boards/at91sam9260-ek/at91sam9260
    ../../../at91lib/boards/at91sam9260-ek/at91sam9260/: AT91SAM9260.h chip.h norflash.icf sdram.icf sram.icf
  group at91lib/memories/sdmmc
    ../../../at91lib/memories/sdmmc/: sdmmc_spi.c sdmmc_spi.h sdspi.c sdspi.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/spi
    ../../../at91lib/peripherals/spi/: spi.c spi.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group basic-sd-spi-project
    ../: main.c
  group documentation
    ../../../: flashloaders.html
    ../../../documentation/: index.html
  group external_libs/crc
    ../../../external_libs/crc/: crc-ccitt.c crc-ccitt.h crc-itu-t.c crc-itu-t.h crc16.c crc16.h crc7.c crc7.h linuxtypes.h
  group resources
    ../../../resources/iar/: at91sam9260-ek-norflash.mac at91sam9260-ek-sdram.mac at91sam9260-ek-sram.mac
