# IAR project at91sam9260-ek.ewp, settings and files
configuration at91sam9260_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9260 Microchip at91sam9260
  ICCARM.CCDefines: at91sam9260; sdram; TRACE_LEVEL=3; usb_HIDAUDIO
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib/usb/device; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9260-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9260; sdram; TRACE_LEVEL=3
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9260-ek
  OBJCOPY.OOCOutputFile: at91sam9260_sdram.bin
  ILINK.IlinkOutputFile: at91sam9260_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9260-ek/at91sam9260/sdram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9260_norflash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9260; norflash; TRACE_LEVEL=3; usb_HIDAUDIO
  AARM.ADefines: at91sam9260; norflash; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam9260_norflash.bin
  ILINK.IlinkOutputFile: at91sam9260_norflash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9260-ek/at91sam9260/norflash.icf
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group .
    ../../../at91sam9260-ek/: usb-device-composite-hidaudio-project
  group at91lib/boards/at91sam9260-ek
    ../../../at91lib/boards/at91sam9260-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9260-ek/at91sam9260
    ../../../at91lib/boards/at91sam9260-ek/at91sam9260/: AT91SAM9260.h chip.h sdram.icf norflash.icf sram.icf
  group at91lib/components/dac-at73c213
    ../../../at91lib/components/dac-at73c213/: at73c213.c at73c213.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pit
    ../../../at91lib/peripherals/pit/: pit.c pit.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/spi
    ../../../at91lib/peripherals/spi/: spi.c spi.h
  group at91lib/peripherals/ssc
    ../../../at91lib/peripherals/ssc/: ssc.c ssc.h
  group at91lib/peripherals/usart
    ../../../at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/usb/common/audio
    ../../../at91lib/usb/common/audio/: AUDControlInterfaceDescriptor.h AUDDataEndpointDescriptor.h AUDDeviceDescriptor.h AUDEndpointDescriptor.h AUDFeatureUnitDescriptor.h AUDFeatureUnitRequest.c AUDFeatureUnitRequest.h AUDFormatTypeOneDescriptor.h AUDGenericDescriptor.h AUDGenericRequest.c AUDGenericRequest.h AUDHeaderDescriptor.h AUDInputTerminalDescriptor.h AUDOutputTerminalDescriptor.h AUDStreamingInterfaceDescriptor.h
  group at91lib/usb/common/core
    ../../../at91lib/usb/common/core/: USBConfigurationDescriptor.c USBConfigurationDescriptor.h USBDeviceDescriptor.h USBDeviceQualifierDescriptor.h USBEndpointDescriptor.c USBEndpointDescriptor.h USBFeatureRequest.c USBFeatureRequest.h USBGenericDescriptor.c USBGenericDescriptor.h USBGenericRequest.c USBGenericRequest.h USBGetDescriptorRequest.c USBGetDescriptorRequest.h USBInterfaceAssociationDescriptor.h USBInterfaceDescriptor.h USBInterfaceRequest.c USBInterfaceRequest.h USBSetAddressRequest.c USBSetAddressRequest.h USBSetConfigurationRequest.c USBSetConfigurationRequest.h USBStringDescriptor.h
  group at91lib/usb/common/hid
    ../../../at91lib/usb/common/hid/: HIDDescriptor.h HIDDeviceDescriptor.h HIDGenericDescriptor.h HIDGenericDesktop.h HIDGenericRequest.h HIDIdleRequest.c HIDIdleRequest.h HIDInterfaceDescriptor.h HIDKeypad.c HIDKeypad.h HIDLeds.h HIDReport.h HIDReportRequest.c HIDReportRequest.h
  group at91lib/usb/device/composite
    ../../../at91lib/usb/device/composite/: AUDDFunctionDriver.c AUDDFunctionDriver.h AUDDFunctionDriverDescriptors.h COMPOSITEDDriver.c COMPOSITEDDriver.h COMPOSITEDDriverDescriptors.c COMPOSITEDDriverDescriptors.h HIDDFunctionDriver.c HIDDFunctionDriver.h HIDDFunctionDriverDescriptors.h
  group at91lib/usb/device/core
    ../../../at91lib/usb/device/core/: USBD.h USBDCallbacks.h USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDDriver.c USBDDriver.h USBDDriverCallbacks.h USBDDriverDescriptors.h USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c
  group at91lib/usb/device/hid-keyboard
    ../../../at91lib/usb/device/hid-keyboard/: HIDDKeyboardCallbacks.h HIDDKeyboardDriver.h HIDDKeyboardDriverDescriptors.h HIDDKeyboardInputReport.c HIDDKeyboardInputReport.h HIDDKeyboardOutputReport.c HIDDKeyboardOutputReport.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h led.c led.h trace.c trace.h
  group usb-device-composite-hidaudio-project
    ../../../at91sam9260-ek/usb-device-composite-hidaudio-project/: main.c
  group resources
    ../../../resources/iar/: at91sam9260-ek-sdram.mac at91sam9260-ek-norflash.mac at91sam9260-ek-sram.mac
