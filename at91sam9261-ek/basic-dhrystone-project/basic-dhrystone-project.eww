<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
	<project>
		<path>$WS_DIR$/ewp/at91sam9261-ek.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>All</name>&gt;
			<member>
				<project>at91sam9261-ek</project>
				<configuration>at91sam9261_sram</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
