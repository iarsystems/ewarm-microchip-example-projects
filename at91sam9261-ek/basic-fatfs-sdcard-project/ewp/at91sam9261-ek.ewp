# IAR project at91sam9261-ek.ewp, settings and files
configuration at91sam9261_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9261 Microchip at91sam9261
  ICCARM.CCDefines: at91sam9261; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91sam9261-ek\basic-fatfs-sdcard-project; ..\..\..\at91lib; ..\..\..\at91lib/peripherals; ..\..\..\external_libs/fat; ..\..\..\at91lib/memories; ..\..\..\at91lib/drivers; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9261-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9261; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9261-ek
  OBJCOPY.OOCOutputFile: at91sam9261_sdram.bin
  ILINK.IlinkOutputFile: at91sam9261_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9261-ek/at91sam9261/sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9261_norflash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9261; norflash; TRACE_LEVEL=4
  AARM.ADefines: at91sam9261; norflash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9261_norflash.bin
  ILINK.IlinkOutputFile: at91sam9261_norflash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9261-ek/at91sam9261/norflash
configuration at91sam9261_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9261; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam9261; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9261_sram.bin
  ILINK.IlinkOutputFile: at91sam9261_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9261-ek/at91sam9261/sram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam9261-ek
    ../../../at91lib/boards/at91sam9261-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9261-ek/at91sam9261
    ../../../at91lib/boards/at91sam9261-ek/at91sam9261/: AT91SAM9261.h chip.h sdram.icf norflash.icf sram.icf
  group at91lib/memories
    ../../../at91lib/memories/: MEDSdcard.c MEDSdcard.h Media.c Media.h
  group at91lib/memories/sdmmc
    ../../../at91lib/memories/sdmmc/: sdmmc_mci.c sdmmc_mci.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/mci
    ../../../at91lib/peripherals/mci/: mci.c mci.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h math.c math.h trace.c trace.h
  group external_libs/fat/fatfs/src
    ../../../external_libs/fat/fatfs/src/: diskio.c diskio.h ff.c ff.h ff_util.c ff_util.h integer.h tff.c
  group basic-fatfs-sdcard-project
    ../../../at91sam9261-ek/basic-fatfs-sdcard-project/: fatfs_config.h main.c
  group resources
    ../../../resources/iar/: at91sam9261-ek-sdram.mac at91sam9261-ek-norflash.mac at91sam9261-ek-sram.mac
