# IAR project at91sam9261-ek.ewp, settings and files
configuration at91sam9261_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9261 Microchip at91sam9261
  ICCARM.CCDefines: at91sam9261; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9261-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9261; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9261-ek
  OBJCOPY.OOCOutputFile: at91sam9261_sdram.bin
  ILINK.IlinkOutputFile: at91sam9261_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9261-ek/at91sam9261/sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9261_norflash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9261; norflash; TRACE_LEVEL=4
  AARM.ADefines: at91sam9261; norflash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9261_norflash.bin
  ILINK.IlinkOutputFile: at91sam9261_norflash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9261-ek/at91sam9261/norflash
configuration at91sam9261_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9261; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam9261; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9261_sram.bin
  ILINK.IlinkOutputFile: at91sam9261_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9261-ek/at91sam9261/sram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group .
    ../../../at91sam9261-ek/: lcd-slideshow-project
  group at91lib/boards/at91sam9261-ek
    ../../../at91lib/boards/at91sam9261-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9261-ek/at91sam9261
    ../../../at91lib/boards/at91sam9261-ek/at91sam9261/: AT91SAM9261.h chip.h sdram.icf norflash.icf sram.icf
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/lcd
    ../../../at91lib/peripherals/lcd/: lcd.c lcd.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/rtt
    ../../../at91lib/peripherals/rtt/: rtt.c rtt.h
  group at91lib/usb/common/cdc
    ../../../at91lib/usb/common/cdc/: CDCAbstractControlManagementDescriptor.h CDCCallManagementDescriptor.h CDCCommunicationInterfaceDescriptor.h CDCDataInterfaceDescriptor.h CDCDeviceDescriptor.h CDCGenericDescriptor.h CDCGenericRequest.h CDCHeaderDescriptor.h CDCLineCoding.c CDCLineCoding.h CDCSetControlLineStateRequest.c CDCSetControlLineStateRequest.h CDCUnionDescriptor.h
  group at91lib/usb/common/core
    ../../../at91lib/usb/common/core/: USBConfigurationDescriptor.c USBConfigurationDescriptor.h USBDeviceDescriptor.h USBDeviceQualifierDescriptor.h USBEndpointDescriptor.c USBEndpointDescriptor.h USBFeatureRequest.c USBFeatureRequest.h USBGenericDescriptor.c USBGenericDescriptor.h USBGenericRequest.c USBGenericRequest.h USBGetDescriptorRequest.c USBGetDescriptorRequest.h USBInterfaceDescriptor.h USBInterfaceRequest.c USBInterfaceRequest.h USBSetAddressRequest.c USBSetAddressRequest.h USBSetConfigurationRequest.c USBSetConfigurationRequest.h USBStringDescriptor.h
  group at91lib/usb/device/cdc-serial
    ../../../at91lib/usb/device/cdc-serial/: CDCDSerialDriver.c CDCDSerialDriver.h CDCDSerialDriverDescriptors.c CDCDSerialDriverDescriptors.h
  group at91lib/usb/device/core
    ../../../at91lib/usb/device/core/: USBD.h USBDCallbacks.h USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c USBDDriver.c USBDDriver.h USBDDriverCallbacks.h USBDDriverCb_CfgChanged.c USBDDriverCb_IfSettingChanged.c USBDDriverDescriptors.h USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c
  group at91lib/utility
    ../../../at91lib/utility/: assert.h bmp.c bmp.h led.c led.h trace.c trace.h
  group lcd-slideshow-project
    ../../../at91sam9261-ek/lcd-slideshow-project/: main.c
  group resources
    ../../../resources/iar/: at91sam9261-ek-sdram.mac at91sam9261-ek-norflash.mac at91sam9261-ek-sram.mac
