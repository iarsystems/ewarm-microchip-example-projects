# IAR project at91sam9263-ek.ewp, settings and files
configuration at91sam9263_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9263 Microchip at91sam9263
  ICCARM.CCDefines: at91sam9263; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/drivers; ..\..\..\at91lib/memories; ..\..\..\at91lib; ..\..\..\external_libs/crc; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9263-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9263; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9263-ek
  OBJCOPY.OOCOutputFile: at91sam9263_sdram.bin
  ILINK.IlinkOutputFile: at91sam9263_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9263-ek/at91sam9263/sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9263_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9263; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam9263; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9263_sram.bin
  ILINK.IlinkOutputFile: at91sam9263_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9263-ek/at91sam9263/sram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam9263-ek
    ../../../at91lib/boards/at91sam9263-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9263-ek/at91sam9263
    ../../../at91lib/boards/at91sam9263-ek/at91sam9263/: AT91SAM9263.h chip.h sdram.icf sram.icf
  group at91lib/memories/sdmmc
    ../../../at91lib/memories/sdmmc/: sdmmc_mci.c sdmmc_mci.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/mci
    ../../../at91lib/peripherals/mci/: mci.c mci.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/rtc
    ../../../at91lib/peripherals/rtc/: rtc.h
  group at91lib/peripherals/tc
    ../../../at91lib/peripherals/tc/: tc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group external_libs/crc
    ../../../external_libs/crc/: crc-itu-t.c crc-itu-t.h crc7.c crc7.h linuxtypes.h
  group basic-sdcard-project
    ../../../at91sam9263-ek/basic-sdcard-project/: main.c
  group resources
    ../../../resources/iar/: at91sam9263-ek-sdram.mac at91sam9263-ek-sram.mac
