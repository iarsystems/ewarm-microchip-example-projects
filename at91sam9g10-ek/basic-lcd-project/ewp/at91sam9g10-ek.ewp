# IAR project at91sam9g10-ek.ewp, settings and files
configuration at91sam9g10_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9g10 Microchip at91sam9g10
  ICCARM.CCDefines: at91sam9g10; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9g10-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9g10; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9g10-ek
  OBJCOPY.OOCOutputFile: at91sam9g10_sdram.bin
  ILINK.IlinkOutputFile: at91sam9g10_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9g10-ek/at91sam9g10/sdram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9g10_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9g10; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam9g10; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9g10_sram.bin
  ILINK.IlinkOutputFile: at91sam9g10_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9g10-ek/at91sam9g10/sram.icf
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group basic-lcd-project
    ../../../at91sam9g10-ek/basic-lcd-project/: image1_rgb.raw image2_rgb.raw main.c
  group at91lib/boards/at91sam9g10-ek
    ../../../at91lib/boards/at91sam9g10-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9g10-ek/at91sam9g10
    ../../../at91lib/boards/at91sam9g10-ek/at91sam9g10/: AT91SAM9G10.h chip.h sdram.icf sram.icf
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/lcd
    ../../../at91lib/peripherals/lcd/: lcd.c lcd.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/rtt
    ../../../at91lib/peripherals/rtt/: rtt.c rtt.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group resources
    ../../../resources/iar/: at91sam9g10-ek-sdram.mac at91sam9g10-ek-sram.mac
