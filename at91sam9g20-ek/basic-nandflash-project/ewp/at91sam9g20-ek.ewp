# IAR project at91sam9g20-ek.ewp, settings and files
configuration at91sam9g20_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9g20 Microchip at91sam9g20
  ICCARM.CCDefines: at91sam9g20; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/memories; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9g20-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9g20; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9g20-ek
  OBJCOPY.OOCOutputFile: at91sam9g20_sdram.bin
  ILINK.IlinkOutputFile: at91sam9g20_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9g20-ek/at91sam9g20/sdram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9g20_norflash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9g20; norflash; TRACE_LEVEL=4
  AARM.ADefines: at91sam9g20; norflash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9g20_norflash.bin
  ILINK.IlinkOutputFile: at91sam9g20_norflash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9g20-ek/at91sam9g20/norflash.icf
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam9g20-ek
    ../../../at91lib/boards/at91sam9g20-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9g20-ek/at91sam9g20
    ../../../at91lib/boards/at91sam9g20-ek/at91sam9g20/: AT91SAM9G20.h chip.h sdram.icf norflash.icf sram.icf
  group at91lib/memories/nandflash
    ../../../at91lib/memories/nandflash/: EccNandFlash.c EccNandFlash.h NandCommon.h NandFlashModel.c NandFlashModel.h NandFlashModelList.c NandFlashModelList.h NandSpareScheme.c NandSpareScheme.h RawNandFlash.c RawNandFlash.h SkipBlockNandFlash.c SkipBlockNandFlash.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h hamming.c hamming.h math.c math.h trace.c trace.h
  group basic-nandflash-project
    ../../../at91sam9g20-ek/basic-nandflash-project/: main.c
  group resources
    ../../../resources/iar/: at91sam9g20-ek-sdram.mac at91sam9g20-ek-norflash.mac at91sam9g20-ek-sram.mac
