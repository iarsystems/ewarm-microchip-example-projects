# IAR project at91sam9g20-ek.ewp, settings and files
configuration at91sam9g20_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9g20 Microchip at91sam9g20
  ICCARM.CCDefines: at91sam9g20; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9g20-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9g20; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9g20-ek
  OBJCOPY.OOCOutputFile: at91sam9g20_sdram.bin
  ILINK.IlinkOutputFile: at91sam9g20_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9g20-ek/at91sam9g20/sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9g20_norflash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9g20; norflash; TRACE_LEVEL=4
  AARM.ADefines: at91sam9g20; norflash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9g20_norflash.bin
  ILINK.IlinkOutputFile: at91sam9g20_norflash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9g20-ek/at91sam9g20/norflash
configuration at91sam9g20_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9g20; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam9g20; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9g20_sram.bin
  ILINK.IlinkOutputFile: at91sam9g20_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9g20-ek/at91sam9g20/sram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam9g20-ek
    ../../../at91lib/boards/at91sam9g20-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9g20-ek/at91sam9g20
    ../../../at91lib/boards/at91sam9g20-ek/at91sam9g20/: AT91SAM9G20.h chip.h sdram.icf norflash.icf sram.icf
  group at91lib/drivers/async
    ../../../at91lib/drivers/async/: async.c async.h
  group at91lib/drivers/twi
    ../../../at91lib/drivers/twi/: twid.c twid.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/twi
    ../../../at91lib/peripherals/twi/: twi.c twi.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h math.c math.h trace.c trace.h
  group basic-twi-eeprom-project
    ../../../at91sam9g20-ek/basic-twi-eeprom-project/: main.c
  group resources
    ../../../resources/iar/: at91sam9g20-ek-sdram.mac at91sam9g20-ek-norflash.mac at91sam9g20-ek-sram.mac
