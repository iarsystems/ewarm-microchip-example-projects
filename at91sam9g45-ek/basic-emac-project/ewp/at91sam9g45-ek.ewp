# IAR project at91sam9g45-ek.ewp, settings and files
configuration at91sam9g45_ddram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9g45 Microchip at91sam9g45
  ICCARM.CCDefines: at91sam9g45; ddram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/utility; ..\..\..\at91lib/boards/at91sam9g45-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9g45; ddram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9g45-ek
  OBJCOPY.OOCOutputFile: at91sam9g45_ddram.bin
  ILINK.IlinkOutputFile: at91sam9g45_ddram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9g45-ek/at91sam9g45/ddram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9g45_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9g45; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam9g45; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9g45_sram.bin
  ILINK.IlinkOutputFile: at91sam9g45_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9g45-ek/at91sam9g45/sram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam9g45-ek
    ../../../at91lib/boards/at91sam9g45-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9g45-ek/at91sam9g45
    ../../../at91lib/boards/at91sam9g45-ek/at91sam9g45/: AT91SAM9G45.h chip.h ddram.icf sram.icf
  group at91lib/drivers/macb
    ../../../at91lib/drivers/macb/: macb.c macb.h mii.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/emac
    ../../../at91lib/peripherals/emac/: emac.c emac.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/rstc
    ../../../at91lib/peripherals/rstc/: rstc.c rstc.h
  group at91lib/peripherals/usart
    ../../../at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group basic-emac-project
    ../../../at91sam9g45-ek/basic-emac-project/: MiniIp.c MiniIp.h main.c
  group resources
    ../../../resources/iar/: at91sam9g45-ek-ddram.mac at91sam9g45-ek-sram.mac
