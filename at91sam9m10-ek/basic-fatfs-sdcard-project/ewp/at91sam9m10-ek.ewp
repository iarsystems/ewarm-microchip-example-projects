# IAR project at91sam9m10-ek.ewp, settings and files
configuration at91sam9m10_ddram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9m10 Microchip at91sam9m10
  ICCARM.CCDefines: at91sam9m10; ddram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91sam9m10-ek\basic-fatfs-sdcard-project; ..\..\..\at91lib; ..\..\..\at91lib/peripherals; ..\..\..\external_libs/fat; ..\..\..\at91lib/memories; ..\..\..\at91lib/drivers; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9m10-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9m10; ddram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9m10-ek
  OBJCOPY.OOCOutputFile: at91sam9m10_ddram.bin
  ILINK.IlinkOutputFile: at91sam9m10_ddram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9m10-ek/at91sam9m10/ddram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9m10_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9m10; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam9m10; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9m10_sram.bin
  ILINK.IlinkOutputFile: at91sam9m10_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9m10-ek/at91sam9m10/sram.icf
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam9m10-ek
    ../../../at91lib/boards/at91sam9m10-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9m10-ek/at91sam9m10
    ../../../at91lib/boards/at91sam9m10-ek/at91sam9m10/: AT91SAM9M10.h chip.h ddram.icf sram.icf
  group at91lib/drivers/dmad
    ../../../at91lib/drivers/dmad/: dmad.c dmad.h
  group at91lib/memories
    ../../../at91lib/memories/: MEDSdcard.c MEDSdcard.h Media.c Media.h
  group at91lib/memories/sdmmc
    ../../../at91lib/memories/sdmmc/: sdmmc_mci.c sdmmc_mci.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/dma
    ../../../at91lib/peripherals/dma/: dma.c dma.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/mci
    ../../../at91lib/peripherals/mci/: mci_hs.c mci_hs.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h math.c math.h trace.c trace.h
  group external_libs/fat/fatfs/src
    ../../../external_libs/fat/fatfs/src/: diskio.c diskio.h ff.c ff.h ff_util.c ff_util.h integer.h tff.c
  group basic-fatfs-sdcard-project
    ../../../at91sam9m10-ek/basic-fatfs-sdcard-project/: fatfs_config.h main.c
  group resources
    ../../../resources/iar/: at91sam9m10-ek-ddram.mac at91sam9m10-ek-sram.mac
