# IAR project at91sam9m10-ek.ewp, settings and files
configuration at91sam9m10_ddram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9m10 Microchip at91sam9m10
  ICCARM.CCDefines: at91sam9m10; ddram; TRACE_LEVEL=3
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/drivers; ..\..\..\at91lib/memories; ..\..\..\at91lib; ..\..\..\external_libs/crc; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9m10-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9m10; ddram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9m10-ek
  OBJCOPY.OOCOutputFile: at91sam9m10_ddram.bin
  ILINK.IlinkOutputFile: at91sam9m10_ddram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9m10-ek/at91sam9m10/ddram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9m10_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9m10; sram; TRACE_LEVEL=3
  AARM.ADefines: at91sam9m10; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9m10_sram.bin
  ILINK.IlinkOutputFile: at91sam9m10_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9m10-ek/at91sam9m10/sram
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group .
    ../../../at91sam9m10-ek/: basic-sdmmc-test-project
  group at91lib/boards/at91sam9m10-ek
    ../../../at91lib/boards/at91sam9m10-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9m10-ek/at91sam9m10
    ../../../at91lib/boards/at91sam9m10-ek/at91sam9m10/: AT91SAM9M10.h chip.h ddram.icf sram.icf
  group at91lib/drivers/dmad
    ../../../at91lib/drivers/dmad/: dmad.c dmad.h
  group at91lib/memories
    ../../../at91lib/memories/: MEDSdmmc.c MEDSdmmc.h Media.c Media.h
  group at91lib/memories/sdmmc
    ../../../at91lib/memories/sdmmc/: sdmmc_mci.c sdmmc_mci.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/dma
    ../../../at91lib/peripherals/dma/: dma.c dma.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/mci
    ../../../at91lib/peripherals/mci/: mci_hs.c mci_hs.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.h
  group at91lib/peripherals/tc
    ../../../at91lib/peripherals/tc/: tc.c tc.h
  group at91lib/usb/common/core
    ../../../at91lib/usb/common/core/: USBConfigurationDescriptor.c USBConfigurationDescriptor.h USBDeviceDescriptor.h USBDeviceQualifierDescriptor.h USBEndpointDescriptor.c USBEndpointDescriptor.h USBFeatureRequest.c USBFeatureRequest.h USBGenericDescriptor.c USBGenericDescriptor.h USBGenericRequest.c USBGenericRequest.h USBGetDescriptorRequest.c USBGetDescriptorRequest.h USBInterfaceDescriptor.h USBInterfaceRequest.c USBInterfaceRequest.h USBSetAddressRequest.c USBSetAddressRequest.h USBSetConfigurationRequest.c USBSetConfigurationRequest.h USBStringDescriptor.h
  group at91lib/usb/common/massstorage
    ../../../at91lib/usb/common/massstorage/: MSDeviceDescriptor.h MSInterfaceDescriptor.h
  group at91lib/usb/device/core
    ../../../at91lib/usb/device/core/: USBD.h USBDCallbacks.h USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c USBDDriver.c USBDDriver.h USBDDriverCallbacks.h USBDDriverCb_IfSettingChanged.c USBDDriverDescriptors.h USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c
  group at91lib/usb/device/massstorage
    ../../../at91lib/usb/device/massstorage/: MSD.h MSDDStateMachine.c MSDDStateMachine.h MSDDriver.c MSDDriver.h MSDDriverDescriptors.c MSDDriverDescriptors.h MSDIOFifo.h MSDLun.c MSDLun.h SBC.h SBCMethods.c SBCMethods.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h led.c led.h math.c math.h trace.c trace.h
  group basic-sdmmc-test-project
    ../../../at91sam9m10-ek/basic-sdmmc-test-project/: main.c
  group resources
    ../../../resources/iar/: at91sam9m10-ek-ddram.mac at91sam9m10-ek-sram.mac
