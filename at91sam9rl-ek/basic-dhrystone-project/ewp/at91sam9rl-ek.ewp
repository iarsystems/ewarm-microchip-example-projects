# IAR project at91sam9rl-ek.ewp, settings and files
configuration at91sam9rl64_sram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9rl64 Microchip at91sam9rl64
  ICCARM.CCDefines: at91sam9rl64; sram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9rl-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9rl64; sram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9rl-ek
  OBJCOPY.OOCOutputFile: at91sam9rl64_sram.bin
  ILINK.IlinkOutputFile: at91sam9rl64_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9rl-ek/at91sam9rl64/sram
  ILINK.IlinkProgramEntryLabel: resetHandler
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam9rl-ek
    ../../../at91lib/boards/at91sam9rl-ek/: board.h board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9rl-ek/at91sam9rl64
    ../../../at91lib/boards/at91sam9rl-ek/at91sam9rl64/: AT91SAM9RL64.h chip.h sdram.icf sram.icf
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.h
  group at91lib/peripherals/rtt
    ../../../at91lib/peripherals/rtt/: rtt.c rtt.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h trace.c trace.h
  group external_libs/dhry
    ../../../external_libs/dhry/: dhry.h dhry_1.c dhry_2.c
  group basic-dhrystone-project
    ../../../at91sam9rl-ek/basic-dhrystone-project/: main.c
  group resources
    ../../../resources/iar/: at91sam9rl-ek-sdram.mac at91sam9rl-ek-sram.mac
