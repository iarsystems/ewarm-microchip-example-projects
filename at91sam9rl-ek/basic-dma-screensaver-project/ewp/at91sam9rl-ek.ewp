# IAR project at91sam9rl-ek.ewp, settings and files
configuration at91sam9rl64_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9rl64 Microchip at91sam9rl64
  ICCARM.CCDefines: at91sam9rl64; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9rl-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9rl64; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9rl-ek
  OBJCOPY.OOCOutputFile: at91sam9rl64_sdram.bin
  ILINK.IlinkOutputFile: at91sam9rl64_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9rl-ek/at91sam9rl64/sdram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9rl64_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9rl64; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam9rl64; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9rl64_sram.bin
  ILINK.IlinkOutputFile: at91sam9rl64_sram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9rl-ek/at91sam9rl64/sram.icf
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group basic-dma-screensaver-project
    ../../../at91sam9rl-ek/basic-dma-screensaver-project/: image.bmp main.c
  group at91lib/boards/at91sam9rl-ek
    ../../../at91lib/boards/at91sam9rl-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9rl-ek/at91sam9rl64
    ../../../at91lib/boards/at91sam9rl-ek/at91sam9rl64/: AT91SAM9RL64.h chip.h sdram.icf sram.icf
  group at91lib/drivers/dmad
    ../../../at91lib/drivers/dmad/: dmad.c dmad.h
  group at91lib/drivers/lcd
    ../../../at91lib/drivers/lcd/: color.h draw.c draw.h font.c font.h font10x14.h lcdd.c lcdd.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/dma
    ../../../at91lib/peripherals/dma/: dma.c dma.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/lcd
    ../../../at91lib/peripherals/lcd/: lcd.c lcd.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.h
  group at91lib/peripherals/rtt
    ../../../at91lib/peripherals/rtt/: rtt.c rtt.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h bmp.c bmp.h rand.c rand.h trace.c trace.h
  group resources
    ../../../resources/iar/: at91sam9rl-ek-sdram.mac at91sam9rl-ek-sram.mac
