# IAR project at91sam9xe-ek.ewp, settings and files
configuration at91sam9xe128_sdram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9xe128 Microchip at91sam9xe128
  ICCARM.CCDefines: at91sam9xe128; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/utility; ..\..\..\at91lib/boards/at91sam9xe-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam9xe128; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam9xe-ek
  OBJCOPY.OOCOutputFile: at91sam9xe128_sdram.bin
  ILINK.IlinkOutputFile: at91sam9xe128_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9xe-ek/at91sam9xe128/sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9xe256_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam9xe256 Microchip at91sam9xe256
  ICCARM.CCDefines: at91sam9xe256; sdram; TRACE_LEVEL=4
  AARM.ADefines: at91sam9xe256; sdram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9xe256_sdram.bin
  ILINK.IlinkOutputFile: at91sam9xe256_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9xe-ek/at91sam9xe256/sdram
configuration at91sam9xe256_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam9xe256 Microchip at91sam9xe256
  ICCARM.CCDefines: at91sam9xe256; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam9xe256; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9xe256_flash.bin
  ILINK.IlinkOutputFile: at91sam9xe256_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9xe-ek/at91sam9xe256/flash
configuration at91sam9xe512_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam9xe512 Microchip at91sam9xe512
  ICCARM.CCDefines: at91sam9xe512; sdram; TRACE_LEVEL=4
  AARM.ADefines: at91sam9xe512; sdram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9xe512_sdram.bin
  ILINK.IlinkOutputFile: at91sam9xe512_sdram.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9xe-ek/at91sam9xe512/sdram
configuration at91sam9xe512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam9xe512 Microchip at91sam9xe512
  ICCARM.CCDefines: at91sam9xe512; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam9xe512; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam9xe512_flash.bin
  ILINK.IlinkOutputFile: at91sam9xe512_flash.out
  ILINK.IlinkIcfFile: ../../../at91lib/boards/at91sam9xe-ek/at91sam9xe512/flash
  group documentation
    ../../../documentation/: index.html
    ../../../: flashloaders.html
  group at91lib/boards/at91sam9xe-ek
    ../../../at91lib/boards/at91sam9xe-ek/: board.h board_lowlevel.c board_memories.c board_memories.h board_cstartup_iar.s
  group at91lib/boards/at91sam9xe-ek/at91sam9xe128
    ../../../at91lib/boards/at91sam9xe-ek/at91sam9xe128/: AT91SAM9XE128.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/boards/at91sam9xe-ek/at91sam9xe256
    ../../../at91lib/boards/at91sam9xe-ek/at91sam9xe256/: AT91SAM9XE256.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/boards/at91sam9xe-ek/at91sam9xe512
    ../../../at91lib/boards/at91sam9xe-ek/at91sam9xe512/: AT91SAM9XE512.h chip.h sdram.icf flash.icf sram.icf
  group at91lib/components/omnivision
    ../../../at91lib/components/omnivision/: omnivision.c omnivision.h
  group at91lib/components/omnivision/ov9655
    ../../../at91lib/components/omnivision/ov9655/: 9655_yuv_cif.h 9655_yuv_qcif.h 9655_yuv_qqcif.h 9655_yuv_qqvga.h 9655_yuv_qvga.h 9655_yuv_sxga.h 9655_yuv_vga.h ov9655.c ov9655.h
  group at91lib/drivers/async
    ../../../at91lib/drivers/async/: async.h
  group at91lib/drivers/twi
    ../../../at91lib/drivers/twi/: twid.c twid.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/isi
    ../../../at91lib/peripherals/isi/: isi.c isi.h isi2.c
  group at91lib/peripherals/lcd
    ../../../at91lib/peripherals/lcd/: lcd.c
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/twi
    ../../../at91lib/peripherals/twi/: twi.c twi.h
  group at91lib/peripherals/usart
    ../../../at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h bmp.c bmp.h math.c math.h trace.c trace.h video.c video.h
  group basic-isi-project
    ../../../at91sam9xe-ek/basic-isi-project/: 2008_RGB_ref.h main.c
  group resources
    ../../../resources/iar/: at91sam9xe-ek-sdram.mac at91sam9xe-ek-flash.mac at91sam9xe-ek-sram.mac
