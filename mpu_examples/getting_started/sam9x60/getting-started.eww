<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/getting-started_sam9x60-ek.ewp</path>
  </project>
</workspace>
