# IAR project getting-started_sam9x25-ek.ewp, settings and files
configuration sam9x25-ek_sram (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9X25 Microchip AT91SAM9X25
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: SOFTPACK_VERSION="2.17"; TRACE_LEVEL=5; VARIANT_SRAM; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9XX5; CONFIG_CHIP_SAM9X25; CONFIG_BOARD_SAM9X25_EK; CONFIG_HAVE_AIC2; CONFIG_HAVE_PIO3; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_DMAC; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H64M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_SHDWC; CONFIG_HAVE_LED; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\Microchip\sam9x35; ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sam9xx5; ..\..\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sam9xx5; ..\..\drivers
  OBJCOPY.OOCOutputFile: getting-started.bin
  ILINK.IlinkOutputFile: getting-started.out
  ILINK.IlinkIcfFile: ../../target/sam9xx5/toolchain/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sam9x25-ek_ddram (ARM, debug)
  as the first configuration, except:
  General.FPU2: 5
  ICCARM.CCDefines: SOFTPACK_VERSION="2.17"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9XX5; CONFIG_CHIP_SAM9X25; CONFIG_BOARD_SAM9X25_EK; CONFIG_HAVE_AIC2; CONFIG_HAVE_PIO3; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_SDRAM; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_DMAC; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H64M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_SHDWC; CONFIG_HAVE_LED; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_SPI_MODE
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: ../../target/sam9xx5/toolchain/iar/ddram.icf
  group (top)
    ../: main.c
  group arch
    ../../arch/arm/: fault_handlers.c l1cache_cp15.c mmu_cp15.c mutex.c
  group drivers
    ../../drivers/irq/: aic2.c irq.c
    ../../drivers/peripherals/: bus.c matrix.c pit.c pmc.c rstc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../drivers/mm/: cache.c
    ../../drivers/serial/: console.c dbgu.c seriald.c uart.c usart.c usartd.c
    ../../drivers/extram/: ddram.c mpddrc.c smc.c
    ../../drivers/dma/: dma.c dma_dmac.c dmac.c
    ../../drivers/led/: led.c
    ../../drivers/gpio/: pio3.c
  group target
    ../../target/common/: board_console.c board_led.c board_timer.c chip_common.c
    ../../target/sam9xx5/: board_sam9xx5-ek.c board_support.c chip.c
    ../../target/sam9xx5/toolchain/iar/: cstartup.s
  group utils
    ../../utils/: callback.c intmath.c rand.c syscalls.c timer.c trace.c
