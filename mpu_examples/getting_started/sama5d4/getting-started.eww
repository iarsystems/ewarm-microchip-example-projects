<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/getting-started_sama5d4-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/getting-started_sama5d4-xplained.ewp</path>
  </project>
</workspace>
