<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/twi_pdc_eeprom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../libraries/libboard_sam3x-ek/build/ewarm/libboard_sam3x-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../libraries/libchip_sam3x/build/ewarm/libchip_sam3x8.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>flash</name>
      <member>
        <project>libchip_sam3x8</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam3x-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>twi_pdc_eeprom</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sram</name>
      <member>
        <project>libchip_sam3x8</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam3x-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>twi_pdc_eeprom</project>
        <configuration>sram</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>libchip_sam3x8</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3x8</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libboard_sam3x-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam3x-ek</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>twi_pdc_eeprom</project>
        <configuration>sram</configuration>
      </member>
      <member>
        <project>twi_pdc_eeprom</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
