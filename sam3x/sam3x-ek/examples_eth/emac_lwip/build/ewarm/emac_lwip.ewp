# IAR project emac_lwip.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Microchip ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../; ../../../../libraries; ../../../../libraries/libboard_sam3x-ek; ../../../../libraries/libchip_sam3x; ../../../../libraries/liblwip/sam3-specific; ../../../../third_party/lwip_1.3.2/src/include; ../../../../third_party/lwip_1.3.2/src/include/ipv4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sam3x8; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Microchip/SAM3X/SAM3X-EK/sam3x8-sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: sam3x8; flash; TRACE_LEVEL=4
  AARM.ADefines: sam3x8; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Microchip/SAM3X/SAM3X-EK/sam3x8-flash.icf
  group (top)
    ../../: httpd.c httpd.h main.c
  group documentation
    ../../../../documentation/html/: emac_lwip.html
    ../../../../../../: flashloaders.html
  group libraries
    ../../../../libraries/libboard_sam3x-ek/lib/: libboard_sam3x_ek_ewarm_dbg.a
    ../../../../libraries/libchip_sam3x/lib/: libchip_sam3x8_ewarm_dbg.a
    ../../../../libraries/liblwip/lib/: liblwip_sam3x_ewarm_dbg.a
  group resources
    $EW_DIR$/arm/config/linker/Microchip/SAM3X/SAM3X-EK/: sam3x8-flash.icf sam3x8-sram.icf
