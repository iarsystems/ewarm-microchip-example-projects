# IAR project emac_uip_webserver.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Microchip ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../; ../../../../libraries; ../../../../libraries/libboard_sam3x-ek; ../../../../libraries/libchip_sam3x; ../../../../libraries/libuip/sam3-specific; ../../../../third_party/uip_1.0/uip; ../../../../third_party/uip_1.0/lib; ../../../../third_party/uip_1.0/apps/dhcpc; ../../../../third_party/uip_1.0/apps/webserver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sam3x8; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Microchip/SAM3X/SAM3X-EK/sam3x8-sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: sam3x8; flash; TRACE_LEVEL=4
  AARM.ADefines: sam3x8; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Microchip/SAM3X/SAM3X-EK/sam3x8-flash.icf
  group (top)
    ../../: main.c uip-conf.h
  group documentation
    ../../../../documentation/html/: emac_uip_webserver.html
    ../../../../../../: flashloaders.html
  group libraries
    ../../../../libraries/libboard_sam3x-ek/lib/: libboard_sam3x_ek_ewarm_dbg.a
    ../../../../libraries/libchip_sam3x/lib/: libchip_sam3x8_ewarm_dbg.a
  group resources
    $EW_DIR$/arm/config/linker/Microchip/SAM3X/SAM3X-EK/: sam3x8-flash.icf sam3x8-sram.icf
  group src_sam3-specific
    ../../../../libraries/libuip/sam3-specific/: clock-arch.c clock-arch.h tapdev.c tapdev.h
  group src_uip/apps/dhcpc
    ../../../../third_party/uip_1.0/apps/dhcpc/: dhcpc.c dhcpc.h
  group src_uip/apps/webserver
    ../../../../third_party/uip_1.0/apps/webserver/: http-strings.c http-strings.h httpd-cgi.c httpd-cgi.h httpd-fs.c httpd-fs.h httpd-fsdata.c httpd-fsdata.h httpd.c httpd.h webserver.h
  group src_uip/lib
    ../../../../third_party/uip_1.0/lib/: memb.c memb.h
  group src_uip/uip
    ../../../../third_party/uip_1.0/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h psock.c psock.h pt.h timer.c timer.h uip-fw.c uip-fw.h uip-neighbor.c uip-neighbor.h uip-split.c uip-split.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uiplib.c uiplib.h uipopt.h
