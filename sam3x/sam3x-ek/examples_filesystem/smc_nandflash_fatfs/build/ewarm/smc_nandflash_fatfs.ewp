# IAR project smc_nandflash_fatfs.ewp, settings and files
configuration flash (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Microchip ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; flash; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_sam3x-ek; ../../../../libraries/libchip_sam3x; ../../../../libraries/memories; ../../../../libraries/libfatfs
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sam3x8; flash; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Microchip/SAM3X/SAM3X-EK/sam3x8-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: main.c
  group libraries
    ../../../../libraries/libboard_sam3x-ek/lib/: libboard_sam3x_ek_ewarm_dbg.a
    ../../../../libraries/libchip_sam3x/lib/: libchip_sam3x8_ewarm_dbg.a
    ../../../../libraries/libfatfs/lib/: libfatfs_sam3x_ewarm_dbg.a
    ../../../../libraries/memories/lib/: libmemories_sam3x_ewarm_dbg.a
  group resources
    $EW_DIR$/arm/config/linker/Microchip/SAM3X/SAM3X-EK/: sam3x8-flash.icf
