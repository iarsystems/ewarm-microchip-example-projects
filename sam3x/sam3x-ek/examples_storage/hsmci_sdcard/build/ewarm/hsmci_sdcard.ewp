# IAR project hsmci_sdcard.ewp, settings and files
configuration flash (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Microchip ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; flash; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../../../libraries; ../../../../libraries/libboard_sam3x-ek; ../../../../libraries/libchip_sam3x; ../../../../libraries/memories; ../../../../libraries/libsdmmc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sam3x8; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Microchip/SAM3X/SAM3X-EK/sam3x8-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: main.c
  group documentation
    ../../../../../../: flashloaders.html
    ../../../../documentation/html/: hsmci_sdcard.html
  group libraries
    ../../../../libraries/libboard_sam3x-ek/lib/: libboard_sam3x_ek_ewarm_dbg.a
    ../../../../libraries/libchip_sam3x/lib/: libchip_sam3x8_ewarm_dbg.a
    ../../../../libraries/memories/lib/: libmemories_sam3x_ewarm_dbg.a
  group resources
    $EW_DIR$/arm/config/linker/Microchip/SAM3X/SAM3X-EK/: sam3x8-flash.icf sam3x8-sram.icf
