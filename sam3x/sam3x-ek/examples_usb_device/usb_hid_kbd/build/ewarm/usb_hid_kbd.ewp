# IAR project usb_hid_kbd.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Microchip ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; sram; TRACE_LEVEL=4; UDD_NO_SLEEP_MGR
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../../../libraries; ../../../../libraries/libboard_sam3x-ek; ../../../../libraries/libchip_sam3x; ../..; ../../../../libraries/usb_device; ../../../../libraries/usb_device/utils; ../../../../libraries/usb_device/drivers/usbb; ../../../../libraries/usb_device/udc; ../../../../libraries/usb_device/class/hid; ../../../../libraries/usb_device/class/hid/device; ../../../../libraries/usb_device/class/hid/device/kbd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sam3x8; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Microchip/SAM3X/SAM3X-EK/sam3x8-sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: sam3x8; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Microchip/SAM3X/SAM3X-EK/sam3x8-flash.icf
  group (top)
    ../../: conf_usb.h main.c main.h ui.c ui.h
  group documentation
    ../../../../../../: flashloaders.html
    ../../../../documentation/html/: usb_hid_kbd.html
  group libraries
    ../../../../libraries/libboard_sam3x-ek/lib/: libboard_sam3x_ek_ewarm_dbg.a
    ../../../../libraries/libchip_sam3x/lib/: libchip_sam3x8_ewarm_dbg.a
  group libraries/usb_device
    ../../../../libraries/usb_device/: usb_atmel.h usb_protocol.h
  group libraries/usb_device/class/hid
    ../../../../libraries/usb_device/class/hid/: usb_protocol_hid.h
  group libraries/usb_device/class/hid/device
    ../../../../libraries/usb_device/class/hid/device/: udi_hid.c udi_hid.h
  group libraries/usb_device/class/hid/device/kbd
    ../../../../libraries/usb_device/class/hid/device/kbd/: udi_hid_kbd.c udi_hid_kbd.h udi_hid_kbd_conf.h udi_hid_kbd_desc.c
  group libraries/usb_device/driver/usbb
    ../../../../libraries/usb_device/drivers/usbb/: usbb_device.c usbb_device.h usbb_otg.h
  group libraries/usb_device/udc
    ../../../../libraries/usb_device/udc/: udc.c udc.h udc_desc.h udd.h udi.h
  group resources
    $EW_DIR$/arm/config/linker/Microchip/SAM3X/SAM3X-EK/: sam3x8-flash.icf sam3x8-sram.icf
