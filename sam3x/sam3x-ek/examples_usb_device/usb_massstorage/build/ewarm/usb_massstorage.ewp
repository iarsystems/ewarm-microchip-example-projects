# IAR project usb_massstorage.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Microchip ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; sram; TRACE_LEVEL=4; UDD_NO_SLEEP_MGR
  ICCARM.CCIncludePath2: ../../../../libraries; ../../../../libraries/libboard_sam3x-ek; ../../../../libraries/libchip_sam3x; ../../../../libraries/memories; ../..; ../../../../libraries/usb_device; ../../../../libraries/usb_device/utils; ../../../../libraries/usb_device/utils/storage/ctrl_access; ../../../../libraries/usb_device/drivers/usbb; ../../../../libraries/usb_device/memory/media_mem; ../../../../libraries/usb_device/memory/nandflash; ../../../../libraries/usb_device/udc; ../../../../libraries/usb_device/class/msc; ../../../../libraries/usb_device/class/msc/device
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sam3x8; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Microchip/SAM3X/SAM3X-EK/sam3x8-sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: sam3x8; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Microchip/SAM3X/SAM3X-EK/sam3x8-flash.icf
  group (top)
    ../../: conf_access.h conf_media_mem.h conf_usb.h main.c main.h ui.c ui.h
  group documentation
    ../../../../../../: flashloaders.html
    ../../../../documentation/html/: usb_massstorage.html
  group libraries
    ../../../../libraries/libboard_sam3x-ek/lib/: libboard_sam3x_ek_ewarm_dbg.a
    ../../../../libraries/libchip_sam3x/lib/: libchip_sam3x8_ewarm_dbg.a
    ../../../../libraries/memories/lib/: libmemories_sam3x_ewarm_dbg.a
  group libraries/memory/media_mem
    ../../../../libraries/usb_device/memory/media_mem/: media_mem.c media_mem.h
  group libraries/usb_device
    ../../../../libraries/usb_device/: usb_atmel.h usb_protocol.h
  group libraries/usb_device/class/msc
    ../../../../libraries/usb_device/class/msc/: sbc_protocol.h spc_protocol.h usb_protocol_msc.h
  group libraries/usb_device/class/msc/device
    ../../../../libraries/usb_device/class/msc/device/: udi_msc.c udi_msc.h udi_msc_conf.h udi_msc_desc.c
  group libraries/usb_device/driver/usbb
    ../../../../libraries/usb_device/drivers/usbb/: usbb_device.c usbb_device.h usbb_otg.h
  group libraries/usb_device/udc
    ../../../../libraries/usb_device/udc/: udc.c udc.h udc_desc.h udd.h udi.h
  group libraries/usb_device/utils/storage/ctrl_access
    ../../../../libraries/usb_device/utils/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group resources
    $EW_DIR$/arm/config/linker/Microchip/SAM3X/SAM3X-EK/: sam3x8-flash.icf sam3x8-sram.icf
