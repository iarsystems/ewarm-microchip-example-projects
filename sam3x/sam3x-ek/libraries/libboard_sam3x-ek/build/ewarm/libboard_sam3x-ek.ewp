# IAR project libboard_sam3x-ek.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Microchip ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../; ../../../libchip_sam3x; ../../../memories/include; ../../../memories/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libboard_sam3x-ek.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam3x8
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../; ../../../libchip_sam3x; ../../../libsdmmc/
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: board.h
  group board
    ../../board/: board_adc.h board_buttons.h board_can.h board_ebi.h board_emac.h board_lcd.h board_leds.h board_mci.h board_nandflash.h board_norflash.h board_pck.h board_pwm.h board_qtouch.h board_sdcard.h board_sdram.h board_smartcard.h board_spi.h board_ssc.h board_touchscreen.h board_twi.h board_uart.h board_usart0.h board_usart1.h board_usart3.h board_usb.h
  group include
    ../../include/: ads7843.h at45_spi.h at45d.h bitbanding.h bmp.h board_lowlevel.h board_memories.h dma_hardware_interface.h dmad.h emacd.h hamming.h hx8347.h iso7816_4.h lcd_color.h lcd_font.h lcd_font10x14.h lcd_gimp_image.h lcdd.h led.h macb.h math.h mii.h rand.h sn65hvd234.h spid_dma.h syscalls.h timetick.h tsd.h tsd_ads7843.h tsd_com.h twid.h uart_console.h usart_spi.h wav.h wm8731.h xmodem.h
  group source
    ../../source/: ads7843.c at45_spi.c at45d.c bmp.c board_cstartup_iar.c board_lowlevel.c board_memories.c dlib_lowlevel.c dma_hardware_interface.c dmad.c emacd.c hamming.c hx8347.c iso7816_4.c lcd_font.c lcd_font10x14.c lcdd.c led.c macb.c math.c rand.c sn65hvd234.c spid_dma.c timetick.c trace.c tsd_ads7843.c tsd_com.c twid.c uart_console.c usart_spi.c wav.c wm8731.c xmodem.c
