<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/libboard_sam3x-ek.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>full</name>
      <member>
        <project>libboard_sam3x-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam3x-ek</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
