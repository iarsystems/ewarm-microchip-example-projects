# IAR project libchip_sam3x8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Microchip ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../; ../../../usb/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libsam3x.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam3x8
  ICCARM.CCIncludePath2: ../../; ../../cmsis; ../../../usb/include
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libchip_sam3x.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: chip.h
  group include
    ../../include/: adc.h async.h can.h chipid.h dacc.h dmac.h eefc.h emac.h exceptions.h flashd.h hsmci.h matrix.h pio.h pio_it.h pio_pin.h pio_pin_it.h pmc.h pwm.h rstc.h rtc.h rtt.h SAM3XA.h sdramc.h smc.h spi.h ssc.h tc.h trace.h trng.h twi.h usart.h wdt.h
  group source
    ../../source/: adc.c async.c can.c chipid.c dacc.c dmac.c eefc.c emac.c exceptions.c flashd.c hsmci.c matrix.c pio.c pio_it.c pio_pin.c pio_pin_it.c pmc.c pwm.c rstc.c rtc.c rtt.c sdramc.c smc.c spi.c ssc.c tc.c trng.c twi.c usart.c wdt.c
