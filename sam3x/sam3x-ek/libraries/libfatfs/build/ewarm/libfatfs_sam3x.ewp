# IAR project libfatfs_sam3x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Microchip ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../; ../../../../libraries/libboard_sam3x-ek; ../../../../libraries/libchip_sam3x; ../../../../libraries/memories
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libboard_sam3x-ek.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam3x8; TRACE_LEVEL=0
  ICCARM.CCIncludePath2: ../../; ../../../../libraries/libboard_sam3x-ek; ../../../../libraries/libchip_sam3x; ../../../../libraries/memories; ../../../../third_party/lwip_1.3.2/src/include/ipv4
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: liblwip_sam3x-ek.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group source
    ../../fatfs/src/: diskio_sam3x.c ff.c
  group source/option
    ../../fatfs/src/option/: ccsbcs.c
