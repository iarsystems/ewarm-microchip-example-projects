# IAR project liblwip_sam3x-ek.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8H Microchip ATSAM3X8H
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../../libboard_sam3x-ek; ../../../libchip_sam3x; ../../sam3-specific; ../../sam3-specific/arch; ../../../../third_party/lwip_1.3.2/src/include; ../../../../third_party/lwip_1.3.2/src/include/ipv4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libboard_sam3x-ek.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam3x8; TRACE_LEVEL=0
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: liblwip_sam3x-ek.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group source/api
    ../../../../third_party/lwip_1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group source/core
    ../../../../third_party/lwip_1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group source/core/ipv4
    ../../../../third_party/lwip_1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group source/include/ipv4/lwip
    ../../../../third_party/lwip_1.3.2/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group source/include/lwip
    ../../../../third_party/lwip_1.3.2/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h udp.h
  group source/include/netif
    ../../../../third_party/lwip_1.3.2/src/include/netif/: etharp.h loopif.h ppp_oe.h slipif.h
  group source/netif
    ../../../../third_party/lwip_1.3.2/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group source/netif/ppp
    ../../../../third_party/lwip_1.3.2/src/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h ppp_oe.c pppdebug.h randm.c randm.h vj.c vj.h vjbsdhdr.h
  group source/sam3-specific
    ../../sam3-specific/: emacif.c emacif.h lwipopts.h
  group source/sam3-specific/arch
    ../../sam3-specific/arch/: cc.h perf.h sys_arch.c sys_arch.h
