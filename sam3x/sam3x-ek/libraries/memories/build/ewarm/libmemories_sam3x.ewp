# IAR project libmemories_sam3x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: sam3x8; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../../libboard_sam3x-ek; ../../../libchip_sam3x; ../../; ../../include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libsam3x.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; sam3x8; TRACE_LEVEL=2
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libmemories_sam3x.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: MEDDdram.c MEDFlash.c Media.c MEDNandFlash.c MEDRamDisk.c MEDSdcard.c MEDSdram.c memories.h
  group include
    ../../include/: at26.h at26d.h EccNandFlash.h ManagedNandFlash.h MappedNandFlash.h MEDDdram.h MEDFlash.h Media.h MEDNandFlash.h MEDRamDisk.h MEDSdcard.h MEDSdram.h NandCommon.h NandFlashModel.h NandFlashModelList.h NandSpareScheme.h NorFlashAmd.h NorFlashApi.h NorFlashCFI.h NorFlashCommon.h NorFlashIntel.h RawNandFlash.h sdio.h sdmmc.h sdmmc_cmd.h SkipBlockNandFlash.h TranslatedNandFlash.h
  group nandflash
    ../../nandflash/: EccNandFlash.c ManagedNandFlash.c MappedNandFlash.c NandFlashDma.c NandFlashModel.c NandFlashModelList.c NandSpareScheme.c NfcRawNandFlash.c RawNandFlash.c SkipBlockNandFlash.c TranslatedNandFlash.c
  group norflash
    ../../norflash/: NorFlashAmd.c NorFlashApi.c NorFlashCFI.c NorFlashCommon.c NorFlashIntel.c
  group sdmmc
    ../../sdmmc/: mcid_dma.c sdmmc.c
