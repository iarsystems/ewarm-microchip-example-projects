<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/clock_example2_flash.ewp</path>
	</project>
</workspace>
