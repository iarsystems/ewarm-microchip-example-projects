<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/cpu_example_flash.ewp</path>
	</project>
</workspace>
