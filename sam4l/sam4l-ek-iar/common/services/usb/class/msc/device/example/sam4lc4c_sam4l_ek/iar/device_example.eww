<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/device_example_flash.ewp</path>
	</project>
</workspace>
