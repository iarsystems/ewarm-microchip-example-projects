# IAR project board_monitor.ewp, settings and files
configuration Board Monitor v1.2 (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3N4A Microchip ATSAM3N4A
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: board_monitor.out
  ILINK.IlinkKeepSymbols: __bin_image
  ILINK.IlinkProgramEntryLabel: __bin_image
configuration Board Monitor v1.3 (ARM, debug)
  as the first configuration, except:
configuration Board Monitor v1.4 (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: readme.c
