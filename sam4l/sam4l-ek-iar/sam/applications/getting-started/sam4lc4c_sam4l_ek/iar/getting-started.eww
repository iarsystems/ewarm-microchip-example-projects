<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/getting-started_flash.ewp</path>
	</project>
</workspace>
