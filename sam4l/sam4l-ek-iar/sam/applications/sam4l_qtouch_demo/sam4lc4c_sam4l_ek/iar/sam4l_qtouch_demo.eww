<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/sam4l_qtouch_demo_flash.ewp</path>
	</project>
</workspace>
