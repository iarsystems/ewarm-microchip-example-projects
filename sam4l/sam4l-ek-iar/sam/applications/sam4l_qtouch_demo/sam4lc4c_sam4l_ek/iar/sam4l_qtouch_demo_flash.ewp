# IAR project sam4l_qtouch_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Microchip ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true; _QTOUCH_
  ICCARM.CCDiagSuppress: Pa050, Go005
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\CMSIS\DSP\Include; ../../../../drivers/lcdca; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../../thirdparty/qtouch/qdebug; ../../../../drivers/pdca; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/include; ../../../../utils/cmsis/sam4l/include; ../../../../utils/cmsis/sam4l/source/templates; ..; ../../../../drivers/ast; ../../qtouch; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../boards/sam4l_ek; ../../../../drivers/wdt; ../../../../drivers/eic; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/services/delay; ../../../../utils; ../../../../components/display/c42364a; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../drivers/flashcalw; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/common; ../../../../../common/services/ioport; ../../../../drivers/bpm; ../..; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true; _QTOUCH_
  AARM.AUserIncludes: ../../../../drivers/lcdca; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../../thirdparty/qtouch/qdebug; ../../../../drivers/pdca; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/include; ../../../../utils/cmsis/sam4l/include; ../../../../utils/cmsis/sam4l/source/templates; ..; ../../../../drivers/ast; ../../qtouch; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../boards/sam4l_ek; ../../../../drivers/wdt; ../../../../drivers/eic; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/services/delay; ../../../../utils; ../../../../components/display/c42364a; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../drivers/flashcalw; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/common; ../../../../../common/services/ioport; ../../../../drivers/bpm; ../..; .
  OBJCOPY.OOCOutputFile: sam4l_qtouch_demo_flash.bin
  ILINK.IlinkOutputFile: sam4l_qtouch_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\CMSIS\Lib\IAR\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCOptLevel: 3
  group common/boards
    ../../../../../common/boards/: board.h
  group common/services/clock
    ../../../../../common/services/clock/: dfll.h genclk.h osc.h pll.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../common/services/clock/sam4l/: dfll.c dfll.h genclk.h osc.c osc.h pll.c pll.h sysclk.c sysclk.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: read.c write.c
  group sam/applications/sam4l_qtouch_demo
    ../../: app.c app.h event.c event.h main.c ui.c ui.h
  group sam/applications/sam4l_qtouch_demo/qtouch
    ../../qtouch/: QDebugSettings.h touch.c touch_config_sam4l.h
  group sam/applications/sam4l_qtouch_demo/sam4lc4c_sam4l_ek
    ../: conf_ast.h conf_board.h conf_c42364a_lcdca.h conf_clock.h conf_lcdca.h conf_sleepmgr.h
  group sam/applications/sam4l_qtouch_demo/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group sam/boards/sam4l_ek
    ../../../../boards/sam4l_ek/: board_monitor.c board_monitor.h init.c led.h sam4l_ek.h
  group sam/components/display/c42364a
    ../../../../components/display/c42364a/: c42364a.h c42364a_lcdca.c c42364a_segmap.h
  group sam/drivers/ast
    ../../../../drivers/ast/: ast.c ast.h
  group sam/drivers/ast/example1
    ../../../../drivers/ast/example1/: ast_example1.h
  group sam/drivers/ast/example2
    ../../../../drivers/ast/example2/: ast_example2.h
  group sam/drivers/bpm
    ../../../../drivers/bpm/: bpm.c bpm.h
  group sam/drivers/eic
    ../../../../drivers/eic/: eic.c eic.h
  group sam/drivers/flashcalw
    ../../../../drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/lcdca
    ../../../../drivers/lcdca/: lcdca.c lcdca.h
  group sam/drivers/lcdca/example
    ../../../../drivers/lcdca/example/: lcdca_example.h
  group sam/drivers/pdca
    ../../../../drivers/pdca/: pdca.c pdca.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/include
    ../../../../utils/cmsis/sam4l/include/: sam4l.h sam4lc2a.h sam4lc2b.h sam4lc2c.h sam4lc4a.h sam4lc4b.h sam4lc4c.h sam4lc8a.h sam4lc8b.h sam4lc8c.h sam4ls2a.h sam4ls2b.h sam4ls2c.h sam4ls4a.h sam4ls4b.h sam4ls4c.h sam4ls8a.h sam4ls8b.h sam4ls8c.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../utils/cmsis/sam4l/include/component/: component_abdacb.h component_acifc.h component_adcife.h component_aesa.h component_ast.h component_bpm.h component_bscif.h component_catb.h component_chipid.h component_crccu.h component_dacc.h component_eic.h component_flashcalw.h component_freqm.h component_gloc.h component_gpio.h component_hcache.h component_hmatrixb.h component_iisc.h component_lcdca.h component_parc.h component_pdca.h component_pevc.h component_picouart.h component_pm.h component_scif.h component_smap.h component_spi.h component_tc.h component_trng.h component_twim.h component_twis.h component_usart.h component_usbc.h component_wdt.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../utils/cmsis/sam4l/include/instance/: instance_abdacb.h instance_acifc.h instance_adcife.h instance_aesa.h instance_ast.h instance_bpm.h instance_bscif.h instance_catb.h instance_chipid.h instance_crccu.h instance_dacc.h instance_eic.h instance_freqm.h instance_gloc.h instance_gpio.h instance_hcache.h instance_hflashc.h instance_hmatrix.h instance_iisc.h instance_lcdca.h instance_parc.h instance_pdca.h instance_pevc.h instance_picouart.h instance_pm.h instance_scif.h instance_smap.h instance_spi.h instance_tc0.h instance_tc1.h instance_trng.h instance_twim0.h instance_twim1.h instance_twim2.h instance_twim3.h instance_twis0.h instance_twis1.h instance_usart0.h instance_usart1.h instance_usart2.h instance_usart3.h instance_usbc.h instance_wdt.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../utils/cmsis/sam4l/include/pio/: pio_sam4lc2a.h pio_sam4lc2b.h pio_sam4lc2c.h pio_sam4lc4a.h pio_sam4lc4b.h pio_sam4lc4c.h pio_sam4lc8a.h pio_sam4lc8b.h pio_sam4lc8c.h pio_sam4ls2a.h pio_sam4ls2b.h pio_sam4ls2c.h pio_sam4ls4a.h pio_sam4ls4b.h pio_sam4ls4c.h pio_sam4ls8a.h pio_sam4ls8b.h pio_sam4ls8c.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../utils/cmsis/sam4l/source/templates/: exceptions.c exceptions.h system_sam4l.c system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group thirdparty/qtouch/devspecific/sam4/sam4l/common
    ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/common/: BitBangSPI_Master.c BitBangSPI_Master.h
  group thirdparty/qtouch/devspecific/sam4/sam4l/include
    ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/include/: touch_api_sam4l.h
  group thirdparty/qtouch/devspecific/sam4/sam4l/lib/iar
    ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/lib/iar/: libsam4l-qt-iar.a
  group thirdparty/qtouch/qdebug
    ../../../../../thirdparty/qtouch/qdebug/: QDebug_sam4l.c QDebug_sam4l.h QDebugTransport.c QDebugTransport.h
