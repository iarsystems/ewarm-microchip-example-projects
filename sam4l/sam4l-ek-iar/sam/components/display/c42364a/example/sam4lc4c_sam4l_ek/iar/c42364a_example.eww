<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/c42364a_example_flash.ewp</path>
	</project>
</workspace>
