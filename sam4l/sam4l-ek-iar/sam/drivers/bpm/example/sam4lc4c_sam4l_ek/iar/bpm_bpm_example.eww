<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/bpm_bpm_example_flash.ewp</path>
	</project>
</workspace>
