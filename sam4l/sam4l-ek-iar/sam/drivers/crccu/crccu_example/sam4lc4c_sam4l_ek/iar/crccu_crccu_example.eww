<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/crccu_crccu_example_flash.ewp</path>
	</project>
</workspace>
