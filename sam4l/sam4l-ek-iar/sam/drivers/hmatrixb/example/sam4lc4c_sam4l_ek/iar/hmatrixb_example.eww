<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/hmatrixb_example_flash.ewp</path>
	</project>
</workspace>
