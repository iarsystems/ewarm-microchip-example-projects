<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/tc_tc_capture_waveform_example_flash.ewp</path>
	</project>
</workspace>
