<?xml version="1.0"?>
<workspace>
	<batchBuild/>
	<project>
		<path>$WS_DIR$/twis_twi_slave_example_flash.ewp</path>
	</project>
</workspace>
