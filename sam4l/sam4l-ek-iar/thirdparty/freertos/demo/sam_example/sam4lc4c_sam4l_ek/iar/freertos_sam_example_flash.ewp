# IAR project freertos_sam_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Microchip ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __FREERTOS__; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCDiagSuppress: Pa050, Go005
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../common/services/serial; ../../../../../../common/utils; ../..; ../../../../../../sam/boards/sam4l_ek; ../../../../../../sam/drivers/wdt; ../../../../freertos-7.0.0/source/portable/iar/sam; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ..; ../../../../../../common/services/delay; ../../../../freertos-7.0.0/source/include; ../../../../../../sam/utils; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/flashcalw; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/bpm; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCOptLevel: 3
  group common/boards
    ../../../../../../common/boards/: board.h
  group common/services/clock
    ../../../../../../common/services/clock/: dfll.h genclk.h osc.h pll.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: dfll.c dfll.h genclk.h osc.c osc.h pll.c pll.h sysclk.c sysclk.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h usart_serial.c
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group sam/boards/sam4l_ek
    ../../../../../../sam/boards/sam4l_ek/: board_monitor.c board_monitor.h init.c led.h sam4l_ek.h
  group sam/drivers/bpm
    ../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/flashcalw
    ../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/include
    ../../../../../../sam/utils/cmsis/sam4l/include/: sam4l.h sam4lc2a.h sam4lc2b.h sam4lc2c.h sam4lc4a.h sam4lc4b.h sam4lc4c.h sam4lc8a.h sam4lc8b.h sam4lc8c.h sam4ls2a.h sam4ls2b.h sam4ls2c.h sam4ls4a.h sam4ls4b.h sam4ls4c.h sam4ls8a.h sam4ls8b.h sam4ls8c.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../sam/utils/cmsis/sam4l/include/component/: component_abdacb.h component_acifc.h component_adcife.h component_aesa.h component_ast.h component_bpm.h component_bscif.h component_catb.h component_chipid.h component_crccu.h component_dacc.h component_eic.h component_flashcalw.h component_freqm.h component_gloc.h component_gpio.h component_hcache.h component_hmatrixb.h component_iisc.h component_lcdca.h component_parc.h component_pdca.h component_pevc.h component_picouart.h component_pm.h component_scif.h component_smap.h component_spi.h component_tc.h component_trng.h component_twim.h component_twis.h component_usart.h component_usbc.h component_wdt.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_abdacb.h instance_acifc.h instance_adcife.h instance_aesa.h instance_ast.h instance_bpm.h instance_bscif.h instance_catb.h instance_chipid.h instance_crccu.h instance_dacc.h instance_eic.h instance_freqm.h instance_gloc.h instance_gpio.h instance_hcache.h instance_hflashc.h instance_hmatrix.h instance_iisc.h instance_lcdca.h instance_parc.h instance_pdca.h instance_pevc.h instance_picouart.h instance_pm.h instance_scif.h instance_smap.h instance_spi.h instance_tc0.h instance_tc1.h instance_trng.h instance_twim0.h instance_twim1.h instance_twim2.h instance_twim3.h instance_twis0.h instance_twis1.h instance_usart0.h instance_usart1.h instance_usart2.h instance_usart3.h instance_usbc.h instance_wdt.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc2a.h pio_sam4lc2b.h pio_sam4lc2c.h pio_sam4lc4a.h pio_sam4lc4b.h pio_sam4lc4c.h pio_sam4lc8a.h pio_sam4lc8b.h pio_sam4lc8c.h pio_sam4ls2a.h pio_sam4ls2b.h pio_sam4ls2c.h pio_sam4ls4a.h pio_sam4ls4b.h pio_sam4ls4c.h pio_sam4ls8a.h pio_sam4ls8b.h pio_sam4ls8c.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c exceptions.h system_sam4l.c system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group thirdparty/freertos/demo/sam_example
    ../../: FreeRTOSConfig.h main.c
  group thirdparty/freertos/demo/sam_example/sam4lc4c_sam4l_ek
    ../: conf_board.h conf_clock.h conf_uart_serial.h
  group thirdparty/freertos/demo/sam_example/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: croutine.c list.c queue.c tasks.c timers.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../freertos-7.0.0/source/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
