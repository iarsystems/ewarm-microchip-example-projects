# IAR project getting_started.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4S16C Microchip SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../../../libraries; ../../../../libraries/libboard_sam4s-ek; ../../../../libraries/libchip_sam4s
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; sram; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: ../../../../libraries/libboard_sam4s-ek/resources/ewarm/sam4s16/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __SAM4S16C__; flash; TRACE_LEVEL=4
  AARM.ADefines: __SAM4S16C__; flash; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: ../../../../libraries/libboard_sam4s-ek/resources/ewarm/sam4s16/flash.icf
  group (top)
    ../../: main.c
  group documentation
    ../../../../../../: flashloaders.html
    ../../../../documentation/html/: getting_started.html
  group libraries
    ../../../../libraries/libboard_sam4s-ek/lib/: libboard_sam4s_ek_ewarm_dbg.a
    ../../../../libraries/libchip_sam4s/lib/: libchip_sam4s16_ewarm_dbg.a
  group resources
    ../../../../libraries/libboard_sam4s-ek/resources/ewarm/sam4s16/: flash.icf sram.icf
