<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/getting_started.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../libraries/libboard_sam4s-ek/build/ewarm/libboard_sam4s-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../libraries/libchip_sam4s/build/ewarm/libchip_sam4s16.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>flash</name>
      <member>
        <project>libchip_sam4s16</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam4s-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>getting_started</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sram</name>
      <member>
        <project>libchip_sam4s16</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam4s-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>eefc_pgm</project>
        <configuration>sram</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>libboard_sam4s-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam4s-ek</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam4s16</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam4s16</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>getting_started</project>
        <configuration>sram</configuration>
      </member>
      <member>
        <project>getting_started</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
