# IAR project ek-demo.ewp, settings and files
configuration flash (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Microchip SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4SD32C__; flash; USE_IAP_FEATURE; TRACE_LEVEL=5; SAM_PORTING=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..\..\src; ..\..\src\fatfs; ..\..\src\nand; ..\..\src\gui-frontends; ..\..\src\gui-backends; ..\..\..\..\libraries; ..\..\..\..\libraries\libboard_sam4s-ek2; ..\..\..\..\libraries\libchip_sam4s; ..\..\..\..\libraries\fat\fatfs\src; ..\..\..\..\libraries\memories; ..\..\..\..\libraries\sam-gui; ..\..\..\..\libraries\libqtouch; ..\..\..\..\libraries\usb\include; ..\..\..\..\libraries\rtos\freertos; ..\..\..\..\libraries\libboard_sam4s-ek2\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sam4s-ek2-demo.bin
  ILINK.IlinkOutputFile: ek-demo.out
  ILINK.IlinkIcfFile: mapping/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../src/: board_dependencies.c board_dependencies.h board_lowlevel_demo.c board_lowlevel_demo.h demo_parameters.c demo_parameters.h main.c
  group bitmaps
    ../../src/bitmaps/: bitmaps.h
  group bitmaps/excluded
    ../../src/bitmaps/: bmp_logo_atmel.c lena128x128x24.c lena128x128x24clr.c lena128x128x8.c lena256x256x8.c
  group fatfs
    ../../../../libraries/fat/fatfs/src/: diskio_rt.c ff.c
  group fatfs/options
    ../../../../libraries/fat/fatfs/src/option/: cc932.c cc936.c cc949.c cc950.c ccsbcs.c
  group gui
    ../../src/gui/: scr_applications.c scr_audio.c scr_disp_demo.c scr_fs_explorer.c scr_infos.c scr_intro.c scr_lp_modes.c scr_lp_modes_backup.c scr_lp_modes_sleep.c scr_lp_modes_wait.c scr_main.c scr_mandelbrot.c scr_ppt.c scr_qtouch.c scr_settings.c scr_settings_backlight.c scr_settings_date.c scr_settings_time.c scr_TSDCalibration.c screens.h
  group gui/backends/HX8347
    ../../src/gui-backends/HX8347/: backend_HX8347.c backend_HX8347.h
  group gui/backends/ILI9325
    ../../src/gui-backends/ILI9325/: backend_ILI9325.c backend_ILI9325.h
  group gui/frontends
    ../../src/gui-frontends/: frontend_ADS7843.c frontend_ADS7843.h frontend_potentiometer.c frontend_potentiometer.h frontend_pushbuttons.c frontend_pushbuttons.h frontend_qtouch.c frontend_qtouch.h
  group libraries
    ../../../../libraries/libqtouch/lib/: libqtouch_sam4s_ewarm_rel.a
  group libraries/debug
    ../../../../libraries/libboard_sam4s-ek2/lib/: libboard_sam4s_ek2_ewarm_dbg.a
    ../../../../libraries/libchip_sam4s/lib/: libchip_sam4sd32c_ewarm_dbg.a
    ../../../../libraries/rtos/FreeRTOS/lib/: libfreertos_ewarm_dbg.a
    ../../../../libraries/memories/lib/: libmemories_sam4s_ewarm_dbg.a
    ../../../../libraries/sam-gui/lib/: libsam_gui_ewarm_dbg.a
    ../../../../libraries/usb/lib/: libusb_sam4s_ewarm_dbg.a
  group mapping
    mapping/: flash.icf
  group nand
    ../../src/nand/: ftldrv.c ftldrv.h MSDLun.c MSDLun.h rtmedia.c rtmedia.h
  group qtouch
    ../../src/qtouch/: qtouch.c qtouch.h
  group usb
    ../../src/usb/: MSDDriverDescriptors.c MSDDriverDescriptors.h usbmsd.c usbmsd.h
