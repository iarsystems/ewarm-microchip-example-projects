<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ek-demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../libraries/libboard_sam4s-ek2/build/ewarm/libboard_sam4s-ek2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../libraries/libchip_sam4s/build/ewarm/libchip_sam4sd32.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../libraries/rtos/FreeRTOS/build/ewarm/libfreertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../libraries/memories/build/ewarm/libmemories_sam4s.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../libraries/sam-gui/build/ewarm/libsam_gui.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/../../../../libraries/usb/build/ewarm/libusb_sam4s.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ek-demo</name>
      <member>
        <project>libchip_sam4sd32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libmemories_sam4s</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusb_sam4s</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libfreertos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libsam_gui</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam4s-ek2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ek-demo</project>
        <configuration>flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
