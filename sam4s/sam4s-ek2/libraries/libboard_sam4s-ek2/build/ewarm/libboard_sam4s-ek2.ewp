# IAR project libboard_sam4s-ek2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Microchip SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4SD32C__; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../; ../../../libchip_sam4s/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libboard_sam4s.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __SAM4SD32C__
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libboard_sam4s-ek2.out
  group (top)
    ../../: board.h
  group include
    ../../include/: ads7843.h at45_spi.h at45d.h bitbanding.h bmp.h board_lowlevel.h board_memories.h clock.h frame_buffer.h hamming.h ili9325.h iso7816_4.h lcd_color.h lcd_draw.h lcd_font.h lcd_font10x14.h lcd_gimp_image.h lcdd.h led.h math.h rand.h timetick.h tsd.h tsd_ads7843.h tsd_com.h uart_console.h wav.h wm8731.h xmodem.h
  group source
    ../../source/: ads7843.c at45_spi.c at45d.c bmp.c board_cstartup_iar.c board_lowlevel.c board_memories.c clock.c frame_buffer.c hamming.c ili9325.c iso7816_4.c lcd_draw.c lcd_font.c lcd_font10x14.c lcdd.c led.c math.c rand.c timetick.c trace.c tsd_ads7843.c tsd_com.c uart_console.c wav.c wm8731.c xmodem.c
