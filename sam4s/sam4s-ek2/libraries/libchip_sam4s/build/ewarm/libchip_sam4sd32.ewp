# IAR project libchip_sam4sd32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Microchip SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4SD32C__; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../; ../../../usb/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libchip_sam4sd32.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __SAM4SD32C__; TRACE_LEVEL=2
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: chip.h
  group include
    ../../include/: acc.h adc.h async.h crccu.h dacc.h efc.h exceptions.h flashd.h hsmci.h pio.h pio_capture.h pio_it.h pmc.h pwmc.h rtc.h rtt.h spi.h spi_pdc.h ssc.h supc.h tc.h trace.h twi.h twid.h usart.h USBD_Config.h USBD_LEDs.h wdt.h
  group source
    ../../source/: acc.c adc.c async.c crccu.c dacc.c efc.c exceptions.c flashd.c hsmci_pdc.c pio.c pio_capture.c pio_it.c pmc.c pwmc.c rtc.c rtt.c spi.c spi_pdc.c ssc.c tc.c twi.c twid.c usart.c USBD_HAL.c wdt.c
