# IAR project libmemories_sam4s.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Microchip SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4SD32C__; TRACE_LEVEL=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../../libboard_sam4s-ek2; ../../../libchip_sam4s; ../../; ../../include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libsam4s.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __SAM4SD32C__; TRACE_LEVEL=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libmemories_sam4s.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: MEDDdram.c MEDFlash.c Media.c MEDNandFlash.c MEDRamDisk.c MEDSdcard.c MEDSdmmc.c MEDSdram.c memories.h
  group nandflash
    ../../nandflash/: EccNandFlash.c ManagedNandFlash.c MappedNandFlash.c NandFlashModel.c NandFlashModelList.c NandSpareScheme.c NfcRawNandFlash.c RawNandFlash.c SkipBlockNandFlash.c TranslatedNandFlash.c
  group norflash
    ../../norflash/: NorFlashAmd.c NorFlashApi.c NorFlashCFI.c NorFlashCommon.c NorFlashIntel.c
  group sdmmc
    ../../sdmmc/: mci_cmd.c mci_cmd_pdc.c sdmmc.c
