# IAR project libfreertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Microchip SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../source/include; ../..; ../../source/portable/IAR/ARM_CM3/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: libsam3s.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ../../source/include; ../..; ../../source/portable/IAR/ARM_CM3
  ILINK.IlinkOutputFile: libboard_sam3s-ek.out
  group (top)
    ../../Source/: list.c queue.c tasks.c
  group include
    ../../Source/include/: FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
    ../../: FreeRTOSConfig.h
  group Portable
    ../../Source/portable/MemMang/: heap_2.c heap_3.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
