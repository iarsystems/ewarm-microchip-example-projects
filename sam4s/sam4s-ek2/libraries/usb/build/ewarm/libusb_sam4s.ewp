# IAR project libusb_sam4s.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Microchip SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4SD32C__; TRACE_LEVEL=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ../../../libboard_sam4s-ek2; ../../../libchip_sam4s; ../../../memories; ../../../usb/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libusb_sam4s.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __SAM4SD32C__
  ICCARM.CCOptLevel: 3
  group include
    ../../include/: AUDDescriptors.h AUDDFunction.h AUDDSpeakerDriver.h AUDDSpeakerPhone.h AUDDSpeakerPhoneDriver.h AUDDStream.h AUDRequests.h CDCAUDDDriver.h CDCDescriptors.h CDCDSerial.h CDCDSerialDriver.h CDCDSerialPort.h CDCHIDDDriver.h CDCMSDDriver.h CDCNotifications.h CDCRequests.h DUALCDCDDriver.h HIDAUDDDriver.h HIDDescriptors.h HIDDFunction.h HIDDKeyboard.h HIDDKeyboardDriver.h HIDDMouseDriver.h HIDDTransferDriver.h HIDMSDDriver.h HIDReports.h HIDRequests.h HIDUsages.h MSD.h MSDDriver.h MSDDStateMachine.h MSDescriptors.h MSDFunction.h MSDIOFifo.h MSDLun.h SBC.h SBCMethods.h USBD.h USBD_HAL.h USBDDriver.h USBDescriptors.h USBLib_Trace.h USBLib_Types.h USBRequests.h
  group source/common
    ../../common/audio/: AUDFeatureUnitRequest.c AUDGenericRequest.c
    ../../common/cdc/: CDCLineCoding.c CDCSetControlLineStateRequest.c
    ../../common/hid/: HIDIdleRequest.c HIDKeypad.c HIDReportRequest.c
    ../../common/core/: USBDescriptors.c USBRequests.c
  group source/device
    ../../device/composite/: AUDDFunction.c CDCAUDDDriver.c CDCHIDDDriver.c CDCMSDDriver.c DUALCDCDDriver.c HIDAUDDDriver.c HIDMSDDriver.c
    ../../device/audio-speaker/: AUDDSpeakerDriver.c AUDDSpeakerDriver_Callbacks.c
    ../../device/audio-speakerphone/: AUDDSpeakerPhoneDriver.c AUDDSpeakerPhoneDriver_Callbacks.c AUDDStream.c
    ../../device/cdc-serial/: CDCDSerial.c CDCDSerialDriver.c CDCDSerialDriver_Callbacks.c CDCDSerialPort.c
    ../../device/hid-transfer/: HIDDFunction.c HIDDTransferDriver.c
    ../../device/hid-keyboard/: HIDDKeyboard.c HIDDKeyboardCallbacks_LedsChanged.c HIDDKeyboardDriver.c HIDDKeyboardInputReport.c HIDDKeyboardOutputReport.c
    ../../device/hid-mouse/: HIDDMouseDriver.c
    ../../device/massstorage/: MSDDriver.c MSDDStateMachine.c MSDFunction.c MSDIOFifo.c MSDLun.c SBCMethods.c
    ../../device/core/: USBD.c USBDCallbacks.c USBDDriver.c USBDDriverCallbacks.c
