# IAR project GettingStarted.ewp, settings and files
configuration SRAM-Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: __SAM9X60__
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DDRAM-Debug (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: GettingStarted.bin
  ILINK.IlinkIcfFile: ddram.icf
  group (top)
    ./: main.c
