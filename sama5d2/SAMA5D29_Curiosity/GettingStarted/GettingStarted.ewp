# IAR project GettingStarted.ewp, settings and files
configuration SRAM-Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D29 Microchip ATSAMA5D29
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCDefines: __SAMA5D29__; DISABLE_CMSIS_INIT
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core_A\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DDRAM-Debug (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: GettingStarted.bin
  ILINK.IlinkIcfFile: ddram.icf
  group (top)
    ./: main.c
