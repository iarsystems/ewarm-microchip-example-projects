# IAR project Loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D29 Microchip ATSAMA5D29
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Loader.srec
  ILINK.IlinkOutputFile: Loader.out
  ILINK.IlinkKeepSymbols: __APP
  ILINK.IlinkConfigDefines: APP_LOAD=0xD8040000
  ILINK.IlinkIcfFile: Loader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: empty.c
