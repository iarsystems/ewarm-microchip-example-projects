<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/GettingStarted.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$/Loader.ewp</path>
    </project>
    <batchBuild/>
</workspace>
