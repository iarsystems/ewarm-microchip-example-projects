# IAR project Loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAMA7D65 Microchip SAMA7D65
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: DISABLE_CMSIS_INIT
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Loader.srec
  ILINK.IlinkOutputFile: Loader.out
  ILINK.IlinkKeepSymbols: __APP
  ILINK.IlinkConfigDefines: APP_LOAD=0x20040000
  ILINK.IlinkIcfFile: Loader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: empty.c
