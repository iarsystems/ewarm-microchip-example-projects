# IAR project samb11_app.ewp, settings and files
configuration Application (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMB11G18A Microchip ATSAMB11G18A
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: samb11_app.bin
  postbuild: isymexport "$TARGET_PATH$" "$TARGET_DIR$\symbols.o" --edit "application_steerfile.cfg"
  ILINK.IlinkOutputFile: samb11_app.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_M.c main.c
