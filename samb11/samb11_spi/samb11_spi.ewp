# IAR project samb11_spi.ewp, settings and files
configuration SPI image creator (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMB11G18A Microchip ATSAMB11G18A
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: samb11_spi.bin
  postbuild: ielftool "$TARGET_PATH$" "$TARGET_PATH$" --fill 0x00;0x0-0xFFF --checksum __FlashHeader0_CRC:4,crc32:i,0xFFFFFFFF;__FlashHeader0-__FlashHeader0_CRC --checksum __FlashHeader1_CRC:4,crc32:i,0xFFFFFFFF;__FlashHeader1-__FlashHeader1_CRC --checksum __FW_CRC:4,crc32:i,0xFFFFFFFF;__FWImageSection-__FW_CRC --checksum __Patch_CRC:4,crc32:i,0xFFFFFFFF;__PatchImageSection-__Patch_CRC --checksum __IMAGE_0_CRC:4,crc32:i,0xFFFFFFFF;__UserAppSection-__IMAGE_0_CRC  --strip
  ILINK.IlinkOutputFile: samb11_image.out
  ILINK.IlinkKeepSymbols: IMAGE_0
  ILINK.IlinkIcfFile: samb11_image.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: flash_header.s fw_image.c readme.txt
    Application/Exe/: symbols.o
