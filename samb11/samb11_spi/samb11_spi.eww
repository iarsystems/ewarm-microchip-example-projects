<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/samb11_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/samb11_spi.ewp</path>
  </project>
  <batchBuild/>
</workspace>
